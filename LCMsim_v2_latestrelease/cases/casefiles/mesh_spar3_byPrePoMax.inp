1724, 431, 1084, 432
1725, 432, 1084, 1085
1726, 432, 1085, 433
1727, 433, 1085, 1086
1728, 433, 1086, 434
1729, 434, 1086, 1087
1730, 434, 1087, 435
1731, 435, 1087, 1088
1732, 435, 1088, 436
1733, 436, 1088, 1089
1734, 436, 1089, 437
1735, 437, 1089, 1090
1736, 437, 1090, 438
1737, 438, 1090, 1091
1738, 438, 1091, 439
1739, 439, 1091, 1092
1740, 439, 1092, 34
1741, 34, 1092, 441
1742, 509, 47, 1083
1743, 1083, 47, 510
1744, 1083, 510, 1084
1745, 1084, 510, 511
1746, 1084, 511, 1085
1747, 1085, 511, 512
1748, 1085, 512, 1086
1749, 1086, 512, 513
1750, 1086, 513, 1087
1751, 1087, 513, 514
1752, 1087, 514, 1088
1753, 1088, 514, 515
1754, 1088, 515, 1089
1755, 1089, 515, 516
1756, 1089, 516, 1090
1757, 1090, 516, 517
1758, 1090, 517, 1091
1759, 1091, 517, 518
1760, 1091, 518, 1092
1761, 1092, 518, 519
1762, 1092, 519, 441
1763, 441, 519, 43
1764, 44, 520, 453
1765, 520, 1093, 453
1766, 520, 521, 1093
1767, 521, 1094, 1093
1768, 521, 48, 1094
1769, 48, 522, 1094
1770, 453, 1093, 454
1771, 1093, 1095, 454
1772, 1093, 1094, 1095
1773, 1094, 1096, 1095
1774, 1094, 522, 1096
1775, 522, 523, 1096
1776, 454, 1095, 40
1777, 1095, 455, 40
1778, 1095, 1096, 455
1779, 1096, 456, 455
1780, 1096, 523, 456
1781, 523, 45, 456
1782, 41, 487, 508
1783, 487, 1097, 508
1784, 487, 486, 1097
1785, 486, 1098, 1097
1786, 486, 485, 1098
1787, 485, 1099, 1098
1788, 485, 484, 1099
1789, 484, 1100, 1099
1790, 484, 483, 1100
1791, 483, 1101, 1100
1792, 483, 482, 1101
1793, 482, 1102, 1101
1794, 482, 481, 1102
1795, 481, 1103, 1102
1796, 481, 480, 1103
1797, 480, 1104, 1103
1798, 480, 479, 1104
1799, 479, 1105, 1104
1800, 479, 478, 1105
1801, 478, 1106, 1105
1802, 478, 477, 1106
1803, 477, 1107, 1106
1804, 477, 476, 1107
1805, 476, 1108, 1107
1806, 476, 475, 1108
1807, 475, 1109, 1108
1808, 475, 474, 1109
1809, 474, 1110, 1109
1810, 474, 473, 1110
1811, 473, 1111, 1110
1812, 473, 472, 1111
1813, 472, 1112, 1111
1814, 472, 471, 1112
1815, 471, 1113, 1112
1816, 471, 470, 1113
1817, 470, 1114, 1113
1818, 470, 469, 1114
1819, 469, 1115, 1114
1820, 469, 468, 1115
1821, 468, 1116, 1115
1822, 468, 467, 1116
1823, 467, 1117, 1116
1824, 467, 466, 1117
1825, 466, 1118, 1117
1826, 466, 465, 1118
1827, 465, 1119, 1118
1828, 465, 464, 1119
1829, 464, 1120, 1119
1830, 464, 463, 1120
1831, 463, 1121, 1120
1832, 463, 462, 1121
1833, 462, 1122, 1121
1834, 462, 461, 1122
1835, 461, 1123, 1122
1836, 461, 460, 1123
1837, 460, 1124, 1123
1838, 460, 459, 1124
1839, 459, 1125, 1124
1840, 459, 458, 1125
1841, 458, 1126, 1125
1842, 458, 457, 1126
1843, 457, 1127, 1126
1844, 457, 45, 1127
1845, 45, 524, 1127
1846, 508, 1097, 46
1847, 1097, 555, 46
1848, 1097, 1098, 555
1849, 1098, 554, 555
1850, 1098, 1099, 554
1851, 1099, 553, 554
1852, 1099, 1100, 553
1853, 1100, 552, 553
1854, 1100, 1101, 552
1855, 1101, 551, 552
1856, 1101, 1102, 551
1857, 1102, 550, 551
1858, 1102, 1103, 550
1859, 1103, 549, 550
1860, 1103, 1104, 549
1861, 1104, 548, 549
1862, 1104, 1105, 548
1863, 1105, 547, 548
1864, 1105, 1106, 547
1865, 1106, 546, 547
1866, 1106, 1107, 546
1867, 1107, 545, 546
1868, 1107, 1108, 545
1869, 1108, 544, 545
1870, 1108, 1109, 544
1871, 1109, 543, 544
1872, 1109, 1110, 543
1873, 1110, 542, 543
1874, 1110, 1111, 542
1875, 1111, 541, 542
1876, 1111, 1112, 541
1877, 1112, 540, 541
1878, 1112, 1113, 540
1879, 1113, 539, 540
1880, 1113, 1114, 539
1881, 1114, 538, 539
1882, 1114, 1115, 538
1883, 1115, 537, 538
1884, 1115, 1116, 537
1885, 1116, 536, 537
1886, 1116, 1117, 536
1887, 1117, 535, 536
1888, 1117, 1118, 535
1889, 1118, 534, 535
1890, 1118, 1119, 534
1891, 1119, 533, 534
1892, 1119, 1120, 533
1893, 1120, 532, 533
1894, 1120, 1121, 532
1895, 1121, 531, 532
1896, 1121, 1122, 531
1897, 1122, 530, 531
1898, 1122, 1123, 530
1899, 1123, 529, 530
1900, 1123, 1124, 529
1901, 1124, 528, 529
1902, 1124, 1125, 528
1903, 1125, 527, 528
1904, 1125, 1126, 527
1905, 1126, 526, 527
1906, 1126, 1127, 526
1907, 1127, 525, 526
1908, 1127, 524, 525
1909, 524, 49, 525
1910, 46, 556, 488
1911, 556, 1128, 488
1912, 556, 50, 1128
1913, 50, 557, 1128
1914, 488, 1128, 489
1915, 1128, 1129, 489
1916, 1128, 557, 1129
1917, 557, 558, 1129
1918, 489, 1129, 490
1919, 1129, 1130, 490
1920, 1129, 558, 1130
1921, 558, 559, 1130
1922, 490, 1130, 491
1923, 1130, 1131, 491
1924, 1130, 559, 1131
1925, 559, 560, 1131
1926, 491, 1131, 492
1927, 1131, 1132, 492
1928, 1131, 560, 1132
1929, 560, 561, 1132
1930, 492, 1132, 493
1931, 1132, 1133, 493
1932, 1132, 561, 1133
1933, 561, 562, 1133
1934, 493, 1133, 494
1935, 1133, 1134, 494
1936, 1133, 562, 1134
1937, 562, 563, 1134
1938, 494, 1134, 495
1939, 1134, 1135, 495
1940, 1134, 563, 1135
1941, 563, 564, 1135
1942, 495, 1135, 496
1943, 1135, 1136, 496
1944, 1135, 564, 1136
1945, 564, 565, 1136
1946, 496, 1136, 497
1947, 1136, 1137, 497
1948, 1136, 565, 1137
1949, 565, 566, 1137
1950, 497, 1137, 498
1951, 1137, 1138, 498
1952, 1137, 566, 1138
1953, 566, 567, 1138
1954, 498, 1138, 499
1955, 1138, 1139, 499
1956, 1138, 567, 1139
1957, 567, 568, 1139
1958, 499, 1139, 500
1959, 1139, 1140, 500
1960, 1139, 568, 1140
1961, 568, 569, 1140
1962, 500, 1140, 501
1963, 1140, 1141, 501
1964, 1140, 569, 1141
1965, 569, 570, 1141
1966, 501, 1141, 502
1967, 1141, 1142, 502
1968, 1141, 570, 1142
1969, 570, 571, 1142
1970, 502, 1142, 503
1971, 1142, 1143, 503
1972, 1142, 571, 1143
1973, 571, 572, 1143
1974, 503, 1143, 504
1975, 1143, 1144, 504
1976, 1143, 572, 1144
1977, 572, 573, 1144
1978, 504, 1144, 505
1979, 1144, 1145, 505
1980, 1144, 573, 1145
1981, 573, 574, 1145
1982, 505, 1145, 506
1983, 1145, 1146, 506
1984, 1145, 574, 1146
1985, 574, 575, 1146
1986, 506, 1146, 507
1987, 1146, 1147, 507
1988, 1146, 575, 1147
1989, 575, 576, 1147
1990, 507, 1147, 42
1991, 1147, 509, 42
1992, 1147, 576, 509
1993, 576, 47, 509
1994, 45, 523, 524
1995, 523, 1148, 524
1996, 523, 522, 1148
1997, 522, 1149, 1148
1998, 522, 48, 1149
1999, 48, 577, 1149
2000, 524, 1148, 49
2001, 1148, 579, 49
2002, 1148, 1149, 579
2003, 1149, 578, 579
2004, 1149, 577, 578
2005, 577, 51, 578
2006, 49, 580, 525
2007, 525, 580, 1150
2008, 525, 1150, 526
2009, 526, 1150, 1151
2010, 526, 1151, 527
2011, 527, 1151, 1152
2012, 527, 1152, 528
2013, 528, 1152, 1153
2014, 528, 1153, 529
2015, 529, 1153, 1154
2016, 529, 1154, 530
2017, 530, 1154, 1155
2018, 530, 1155, 531
2019, 531, 1155, 1156
2020, 531, 1156, 532
2021, 532, 1156, 1157
2022, 532, 1157, 533
2023, 533, 1157, 1158
2024, 533, 1158, 534
2025, 534, 1158, 1159
2026, 534, 1159, 535
2027, 535, 1159, 1160
2028, 535, 1160, 536
2029, 536, 1160, 1161
2030, 536, 1161, 537
2031, 537, 1161, 1162
2032, 537, 1162, 538
2033, 538, 1162, 1163
2034, 538, 1163, 539
2035, 539, 1163, 1164
2036, 539, 1164, 540
2037, 540, 1164, 1165
2038, 540, 1165, 541
2039, 541, 1165, 1166
2040, 541, 1166, 542
2041, 542, 1166, 1167
2042, 542, 1167, 543
2043, 543, 1167, 1168
2044, 543, 1168, 544
2045, 544, 1168, 1169
2046, 544, 1169, 545
2047, 545, 1169, 1170
2048, 545, 1170, 546
2049, 546, 1170, 1171
2050, 546, 1171, 547
2051, 547, 1171, 1172
2052, 547, 1172, 548
2053, 548, 1172, 1173
2054, 548, 1173, 549
2055, 549, 1173, 1174
2056, 549, 1174, 550
2057, 550, 1174, 1175
2058, 550, 1175, 551
2059, 551, 1175, 1176
2060, 551, 1176, 552
2061, 552, 1176, 1177
2062, 552, 1177, 553
2063, 553, 1177, 1178
2064, 553, 1178, 554
2065, 554, 1178, 1179
2066, 554, 1179, 555
2067, 555, 1179, 1180
2068, 555, 1180, 46
2069, 46, 1180, 556
2070, 580, 52, 1150
2071, 1150, 52, 581
2072, 1150, 581, 1151
2073, 1151, 581, 582
2074, 1151, 582, 1152
2075, 1152, 582, 583
2076, 1152, 583, 1153
2077, 1153, 583, 584
2078, 1153, 584, 1154
2079, 1154, 584, 585
2080, 1154, 585, 1155
2081, 1155, 585, 586
2082, 1155, 586, 1156
2083, 1156, 586, 587
2084, 1156, 587, 1157
2085, 1157, 587, 588
2086, 1157, 588, 1158
2087, 1158, 588, 589
2088, 1158, 589, 1159
2089, 1159, 589, 590
2090, 1159, 590, 1160
2091, 1160, 590, 591
2092, 1160, 591, 1161
2093, 1161, 591, 592
2094, 1161, 592, 1162
2095, 1162, 592, 593
2096, 1162, 593, 1163
2097, 1163, 593, 594
2098, 1163, 594, 1164
2099, 1164, 594, 595
2100, 1164, 595, 1165
2101, 1165, 595, 596
2102, 1165, 596, 1166
2103, 1166, 596, 597
2104, 1166, 597, 1167
2105, 1167, 597, 598
2106, 1167, 598, 1168
2107, 1168, 598, 599
2108, 1168, 599, 1169
2109, 1169, 599, 600
2110, 1169, 600, 1170
2111, 1170, 600, 601
2112, 1170, 601, 1171
2113, 1171, 601, 602
2114, 1171, 602, 1172
2115, 1172, 602, 603
2116, 1172, 603, 1173
2117, 1173, 603, 604
2118, 1173, 604, 1174
2119, 1174, 604, 605
2120, 1174, 605, 1175
2121, 1175, 605, 606
2122, 1175, 606, 1176
2123, 1176, 606, 607
2124, 1176, 607, 1177
2125, 1177, 607, 608
2126, 1177, 608, 1178
2127, 1178, 608, 609
2128, 1178, 609, 1179
2129, 1179, 609, 610
2130, 1179, 610, 1180
2131, 1180, 610, 611
2132, 1180, 611, 556
2133, 556, 611, 50
2134, 51, 612, 578
2135, 612, 1181, 578
2136, 612, 53, 1181
2137, 53, 613, 1181
2138, 578, 1181, 579
2139, 1181, 1182, 579
2140, 1181, 613, 1182
2141, 613, 614, 1182
2142, 579, 1182, 49
2143, 1182, 580, 49
2144, 1182, 614, 580
2145, 614, 52, 580
**
** Node sets +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Element sets ++++++++++++++++++++++++++++++++++++++++++++
**
**
** Surfaces ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Physical constants ++++++++++++++++++++++++++++++++++++++
**
**
** Materials +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Sections ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Pre-tension sections ++++++++++++++++++++++++++++++++++++
**
**
** Constraints +++++++++++++++++++++++++++++++++++++++++++++
**
**
** Surface interactions ++++++++++++++++++++++++++++++++++++
**
**
** Contact pairs +++++++++++++++++++++++++++++++++++++++++++
**
**
** Amplitudes ++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Initial conditions ++++++++++++++++++++++++++++++++++++++
**
**
** Steps +++++++++++++++++++++++++++++++++++++++++++++++++++
**
