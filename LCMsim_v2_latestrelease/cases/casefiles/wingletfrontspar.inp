**
** Heading +++++++++++++++++++++++++++++++++++++++++++++++++
**
*Heading
Hash: hxMZWI5Y, Date: 04/03/2025, Unit system: M_KG_S_C
**
** Nodes +++++++++++++++++++++++++++++++++++++++++++++++++++
**
*Node
1, 1.30558006E+001, 2.07338173E-001, -1.39109750E+000
2, 1.30270435E+001, 2.04988604E-001, -1.39058266E+000
3, 1.29635604E+001, 1.77333621E-001, -1.58063785E+000
4, 1.29920516E+001, 1.80339432E-001, -1.58063741E+000
5, 1.31211306E+001, 2.73908222E-001, -1.21246190E+000
6, 1.30925618E+001, 2.71365254E-001, -1.21133746E+000
7, 1.30186093E+001, 1.96634229E-001, -1.38966719E+000
8, 1.29555098E+001, 1.68823779E-001, -1.58063524E+000
9, 1.29499904E+001, 1.75045519E-001, -1.62383074E+000
10, 1.29789479E+001, 1.78184628E-001, -1.62200928E+000
11, 1.31860388E+001, 3.67611857E-001, -1.04582119E+000
12, 1.31574072E+001, 3.64380791E-001, -1.04376574E+000
13, 1.30839493E+001, 2.62857320E-001, -1.20945348E+000
14, 1.30137418E+001, 1.08457428E-001, -1.38081919E+000
15, 1.29543749E+001, 7.34251710E-002, -1.58063020E+000
16, 1.29546638E+001, 8.24891367E-002, -1.58068265E+000
17, 1.29550721E+001, 1.57478417E-001, -1.58055031E+000
18, 1.29420138E+001, 1.66466941E-001, -1.62434213E+000
19, 1.33314882E+001, 5.86361578E-001, -7.39359905E-001
20, 1.33022705E+001, 5.82987900E-001, -7.35976844E-001
21, 1.31490460E+001, 3.55877838E-001, -1.04097020E+000
22, 1.30768261E+001, 1.82198060E-001, -1.19309864E+000
23, 1.30217553E+001, 9.98697358E-002, -1.38002847E+000
24, 1.29627984E+001, 6.50098209E-002, -1.58063788E+000
25, 1.29218409E+001, 8.25151559E-002, -1.69509844E+000
26, 1.29216843E+001, 1.57457534E-001, -1.69511110E+000
27, 1.29414070E+001, 1.57402012E-001, -1.62676929E+000
28, 1.29516930E+001, 7.28282926E-002, -1.59098611E+000
29, 1.29516981E+001, 8.24274269E-002, -1.59163931E+000
30, 1.36261954E+001, 9.31173171E-001, -3.39783241E-001
31, 1.35933356E+001, 9.29570882E-001, -3.36425486E-001
32, 1.32942221E+001, 5.75191360E-001, -7.31473873E-001
33, 1.31447253E+001, 2.82389642E-001, -1.01948291E+000
34, 1.30846617E+001, 1.73490698E-001, -1.19151078E+000
35, 1.30491978E+001, 9.88745797E-002, -1.38021543E+000
36, 1.29899708E+001, 6.44220933E-002, -1.58063775E+000
37, 1.29596212E+001, 6.43547880E-002, -1.59204931E+000
38, 1.36520571E+001, 9.55261427E-001, -3.14065390E-001
39, 1.36186292E+001, 9.53668273E-001, -3.10777315E-001
40, 1.35863382E+001, 9.25144647E-001, -3.28679755E-001
41, 1.32933100E+001, 5.21072075E-001, -7.03355930E-001
42, 1.31528509E+001, 2.74076145E-001, -1.01735321E+000
43, 1.31121242E+001, 1.72607866E-001, -1.19193393E+000
44, 1.36114751E+001, 9.49294107E-001, -3.03111289E-001
45, 1.35926634E+001, 9.10413623E-001, -3.03204877E-001
46, 1.33018460E+001, 5.13605662E-001, -6.99997095E-001
47, 1.31803943E+001, 2.73914059E-001, -1.01841420E+000
48, 1.36169899E+001, 9.35924005E-001, -2.79975842E-001
49, 1.36043186E+001, 9.06162074E-001, -2.96017064E-001
50, 1.33299701E+001, 5.13767477E-001, -7.01643199E-001
51, 1.36287562E+001, 9.31679489E-001, -2.72815319E-001
52, 1.36366419E+001, 9.06062563E-001, -2.96331091E-001
53, 1.36615030E+001, 9.31571550E-001, -2.73087411E-001
54, 1.30204936E+001, 2.00946604E-001, -1.40930784E+000
55, 1.30139200E+001, 1.97150260E-001, -1.42829428E+000
56, 1.30074542E+001, 1.93675546E-001, -1.44716203E+000
57, 1.30010324E+001, 1.90484196E-001, -1.46609473E+000
58, 1.29946559E+001, 1.87576884E-001, -1.48508839E+000
59, 1.29883260E+001, 1.84954223E-001, -1.50413900E+000
60, 1.29821067E+001, 1.82638728E-001, -1.52305125E+000
61, 1.29758115E+001, 1.80565007E-001, -1.54239498E+000
62, 1.29696910E+001, 1.78815616E-001, -1.56140011E+000
63, 1.29993993E+001, 1.82104363E-001, -1.55782408E+000
64, 1.30088217E+001, 1.84909210E-001, -1.52895771E+000
65, 1.30187952E+001, 1.88519740E-001, -1.49886411E+000
66, 1.30286238E+001, 1.92702131E-001, -1.46965558E+000
67, 1.30375178E+001, 1.97004623E-001, -1.44359638E+000
68, 1.30476660E+001, 2.02497466E-001, -1.41428152E+000
69, 1.30861704E+001, 2.62895560E-001, -1.22857862E+000
70, 1.30797353E+001, 2.54823858E-001, -1.24599356E+000
71, 1.30731296E+001, 2.47004625E-001, -1.26392743E+000
72, 1.30666153E+001, 2.39748119E-001, -1.28166865E+000
73, 1.30600665E+001, 2.32900366E-001, -1.29955896E+000
74, 1.30535520E+001, 2.26526857E-001, -1.31740909E+000
75, 1.30469433E+001, 2.20501802E-001, -1.33557132E+000
76, 1.30403091E+001, 2.14894446E-001, -1.35385760E+000
77, 1.30336525E+001, 2.09707395E-001, -1.37225943E+000
78, 1.30644648E+001, 2.13513732E-001, -1.36709658E+000
79, 1.30738202E+001, 2.21063761E-001, -1.34128398E+000
80, 1.30841087E+001, 2.30440719E-001, -1.31302253E+000
81, 1.30934715E+001, 2.39971185E-001, -1.28742003E+000
82, 1.31034052E+001, 2.51146539E-001, -1.26038080E+000
83, 1.31128566E+001, 2.62824005E-001, -1.23477627E+000
84, 1.30120427E+001, 1.92580695E-001, -1.40868431E+000
85, 1.30055807E+001, 1.88841123E-001, -1.42758299E+000
86, 1.29992233E+001, 1.85408058E-001, -1.44635751E+000
87, 1.29928432E+001, 1.82212817E-001, -1.46538348E+000
88, 1.29864431E+001, 1.79264249E-001, -1.48465899E+000
89, 1.29801508E+001, 1.76621315E-001, -1.50379859E+000
90, 1.29739662E+001, 1.74276273E-001, -1.52279696E+000
91, 1.29677658E+001, 1.72182206E-001, -1.54203419E+000
92, 1.29616132E+001, 1.70364590E-001, -1.56131487E+000
93, 1.29853163E+001, 1.79231863E-001, -1.60190255E+000
94, 1.29567754E+001, 1.76189570E-001, -1.60223430E+000
95, 1.31507499E+001, 3.54438552E-001, -1.06008929E+000
96, 1.31440635E+001, 3.44539451E-001, -1.07667728E+000
97, 1.31374812E+001, 3.34880259E-001, -1.09319999E+000
98, 1.31309369E+001, 3.25362992E-001, -1.10981991E+000
99, 1.31244962E+001, 3.16081411E-001, -1.12636814E+000
100, 1.31180292E+001, 3.06848712E-001, -1.14317774E+000
101, 1.31116018E+001, 2.97760064E-001, -1.16008075E+000
102, 1.31051507E+001, 2.88727449E-001, -1.17724632E+000
103, 1.30988676E+001, 2.80017662E-001, -1.19416191E+000
104, 1.31282573E+001, 2.83794070E-001, -1.19316700E+000
105, 1.31360766E+001, 2.94760756E-001, -1.17229455E+000
106, 1.31450541E+001, 3.07502924E-001, -1.14870499E+000
107, 1.31538530E+001, 3.20144173E-001, -1.12596349E+000
108, 1.31627275E+001, 3.33043014E-001, -1.10339666E+000
109, 1.31707517E+001, 3.44831776E-001, -1.08330402E+000
110, 1.31789678E+001, 3.57023436E-001, -1.06303083E+000
111, 1.30774273E+001, 2.54346278E-001, -1.22718494E+000
112, 1.30709946E+001, 2.46381432E-001, -1.24473167E+000
113, 1.30645911E+001, 2.38869391E-001, -1.26225478E+000
114, 1.30580903E+001, 2.31661471E-001, -1.28010110E+000
115, 1.30515591E+001, 2.24838393E-001, -1.29808710E+000
116, 1.30450003E+001, 2.18402944E-001, -1.31620543E+000
117, 1.30384166E+001, 2.12357752E-001, -1.33444870E+000
118, 1.30318106E+001, 2.06705286E-001, -1.35280946E+000
119, 1.30251851E+001, 2.01447852E-001, -1.37128021E+000
120, 1.30175968E+001, 1.78293455E-001, -1.38782680E+000
121, 1.30162826E+001, 1.54485718E-001, -1.38543784E+000
122, 1.30148613E+001, 1.28738092E-001, -1.38285423E+000
123, 1.30081896E+001, 1.03594871E-001, -1.39861480E+000
124, 1.30026622E+001, 9.90638788E-002, -1.41650537E+000
125, 1.29971612E+001, 9.48659109E-002, -1.43448511E+000
126, 1.29916886E+001, 9.10023197E-002, -1.45254825E+000
127, 1.29862459E+001, 8.74743497E-002, -1.47068897E+000
128, 1.29808350E+001, 8.42831373E-002, -1.48890141E+000
129, 1.29754576E+001, 8.14297105E-002, -1.50717971E+000
130, 1.29701155E+001, 7.89149885E-002, -1.52551799E+000
131, 1.29648103E+001, 7.67397815E-002, -1.54391034E+000
132, 1.29595438E+001, 7.49047900E-002, -1.56235082E+000
133, 1.29547908E+001, 1.05810803E-001, -1.58064150E+000
134, 1.29549460E+001, 1.34306730E-001, -1.58059121E+000
135, 1.29487483E+001, 1.67643003E-001, -1.60253239E+000
136, 1.31949547E+001, 3.81294788E-001, -1.02424112E+000
137, 1.32052161E+001, 3.96990604E-001, -9.99935949E-001
138, 1.32146677E+001, 4.11400494E-001, -9.78031275E-001
139, 1.32238281E+001, 4.25325002E-001, -9.57224830E-001
140, 1.32343791E+001, 4.41314477E-001, -9.33756252E-001
141, 1.32452230E+001, 4.57695954E-001, -9.10167015E-001
142, 1.32560736E+001, 4.74036764E-001, -8.87080159E-001
143, 1.32670714E+001, 4.90549712E-001, -8.64186267E-001
144, 1.32780659E+001, 5.07009644E-001, -8.41788903E-001
145, 1.32893530E+001, 5.23859829E-001, -8.19284899E-001
146, 1.33007843E+001, 5.40877345E-001, -7.96980399E-001
147, 1.33122032E+001, 5.57830358E-001, -7.75170924E-001
148, 1.33228180E+001, 5.73549649E-001, -7.55304626E-001
149, 1.32944300E+001, 5.71318945E-001, -7.50527582E-001
150, 1.32864954E+001, 5.59493681E-001, -7.65464321E-001
151, 1.32789319E+001, 5.48205959E-001, -7.79905040E-001
152, 1.32711227E+001, 5.36534849E-001, -7.95027914E-001
153, 1.32635290E+001, 5.25169664E-001, -8.09945439E-001
154, 1.32561477E+001, 5.14106304E-001, -8.24651568E-001
155, 1.32486777E+001, 5.02893686E-001, -8.39745910E-001
156, 1.32412706E+001, 4.91758851E-001, -8.54928577E-001
157, 1.32339267E+001, 4.80702284E-001, -8.70198908E-001
158, 1.32266464E+001, 4.69724466E-001, -8.85556240E-001
159, 1.32194300E+001, 4.58825873E-001, -9.00999904E-001
160, 1.32122778E+001, 4.48006980E-001, -9.16529228E-001
161, 1.32051900E+001, 4.37268259E-001, -9.32143536E-001
162, 1.31980273E+001, 4.26397839E-001, -9.48156977E-001
163, 1.31910708E+001, 4.15822484E-001, -9.63940878E-001
164, 1.31843168E+001, 4.05537773E-001, -9.79489557E-001
165, 1.31774901E+001, 3.95124372E-001, -9.95436974E-001
166, 1.31705949E+001, 3.84587668E-001, -1.01178735E+000
167, 1.31639018E+001, 3.74341322E-001, -1.02789878E+000
168, 1.31422986E+001, 3.45826589E-001, -1.05754667E+000
169, 1.31356549E+001, 3.36018148E-001, -1.07405993E+000
170, 1.31290484E+001, 3.26353040E-001, -1.09067233E+000
171, 1.31225451E+001, 3.16926503E-001, -1.10721500E+000
172, 1.31160141E+001, 3.07548829E-001, -1.12402086E+000
173, 1.31095218E+001, 2.98316677E-001, -1.14092202E+000
174, 1.31030043E+001, 2.89140639E-001, -1.15808759E+000
175, 1.30965912E+001, 2.80203123E-001, -1.17517635E+000
176, 1.30902819E+001, 2.71500398E-001, -1.19218422E+000
177, 1.30816913E+001, 2.37288335E-001, -1.20426900E+000
178, 1.30789559E+001, 2.06315179E-001, -1.19798874E+000
179, 1.30708898E+001, 1.73806774E-001, -1.20939404E+000
180, 1.30649861E+001, 1.65743683E-001, -1.22586603E+000
181, 1.30591171E+001, 1.58011827E-001, -1.24250838E+000
182, 1.30532853E+001, 1.50614120E-001, -1.25931483E+000
183, 1.30474926E+001, 1.43553352E-001, -1.27627903E+000
184, 1.30417413E+001, 1.36832186E-001, -1.29339460E+000
185, 1.30360337E+001, 1.30453155E-001, -1.31065507E+000
186, 1.30303717E+001, 1.24418664E-001, -1.32805395E+000
187, 1.30247576E+001, 1.18730989E-001, -1.34558466E+000
188, 1.30191935E+001, 1.13392274E-001, -1.36324061E+000
189, 1.30162493E+001, 9.50090517E-002, -1.39789954E+000
190, 1.30107662E+001, 9.04826769E-002, -1.41586521E+000
191, 1.30053079E+001, 8.62920813E-002, -1.43391964E+000
192, 1.29998760E+001, 8.24386260E-002, -1.45205698E+000
193, 1.29944724E+001, 7.89235623E-002, -1.47027133E+000
194, 1.29890988E+001, 7.57480318E-002, -1.48855678E+000
195, 1.29837569E+001, 7.29130658E-002, -1.50690739E+000
196, 1.29784485E+001, 7.04195850E-002, -1.52531720E+000
197, 1.29731753E+001, 6.82683991E-002, -1.54378022E+000
198, 1.29679391E+001, 6.64602067E-002, -1.56229048E+000
199, 1.29217626E+001, 1.19986345E-001, -1.69510477E+000
200, 1.29294945E+001, 1.57435548E-001, -1.66804774E+000
201, 1.29362199E+001, 1.57416615E-001, -1.64474319E+000
202, 1.29460253E+001, 8.24440954E-002, -1.61129654E+000
203, 1.29381131E+001, 8.24673436E-002, -1.63871321E+000
204, 1.29299620E+001, 8.24912937E-002, -1.66695756E+000
205, 1.36097326E+001, 9.30370424E-001, -3.38101006E-001
206, 1.35815153E+001, 9.18086538E-001, -3.48740516E-001
207, 1.35701662E+001, 9.06913334E-001, -3.60786039E-001
208, 1.35589395E+001, 8.95714566E-001, -3.72922153E-001
209, 1.35475012E+001, 8.84150412E-001, -3.85520011E-001
210, 1.35365250E+001, 8.72901804E-001, -3.97837812E-001
211, 1.35256732E+001, 8.61629666E-001, -4.10243989E-001
212, 1.35146232E+001, 8.49992049E-001, -4.23117760E-001
213, 1.35040259E+001, 8.38674211E-001, -4.35701079E-001
214, 1.34935549E+001, 8.27334889E-001, -4.48370509E-001
215, 1.34828993E+001, 8.15630196E-001, -4.61513128E-001
216, 1.34726867E+001, 8.04249340E-001, -4.74355057E-001
217, 1.34626022E+001, 7.92849057E-001, -4.87280788E-001
218, 1.34523469E+001, 7.81083712E-001, -5.00685041E-001
219, 1.34425245E+001, 7.69646085E-001, -5.13778533E-001
220, 1.34328322E+001, 7.58191099E-001, -5.26953470E-001
221, 1.34229827E+001, 7.46371560E-001, -5.40612000E-001
222, 1.34135561E+001, 7.34883438E-001, -5.53949868E-001
223, 1.34042612E+001, 7.23380036E-001, -5.67366780E-001
224, 1.33948230E+001, 7.11512790E-001, -5.81272091E-001
225, 1.33857972E+001, 6.99980479E-001, -5.94847014E-001
226, 1.33769048E+001, 6.88434974E-001, -6.08498537E-001
227, 1.33678831E+001, 6.76526535E-001, -6.22642997E-001
228, 1.33592631E+001, 6.64956365E-001, -6.36447525E-001
229, 1.33507782E+001, 6.53375094E-001, -6.50326167E-001
230, 1.33421778E+001, 6.41431996E-001, -6.64702012E-001
231, 1.33339684E+001, 6.29830318E-001, -6.78728569E-001
232, 1.33258955E+001, 6.18219638E-001, -6.92826711E-001
233, 1.33177212E+001, 6.06248437E-001, -7.07426052E-001
234, 1.33099269E+001, 5.94621617E-001, -7.21666939E-001
235, 1.33401742E+001, 5.99396926E-001, -7.23321241E-001
236, 1.33512196E+001, 6.15584833E-001, -7.03501963E-001
237, 1.33627860E+001, 6.32101929E-001, -6.83392300E-001
238, 1.33748901E+001, 6.48944618E-001, -6.63003907E-001
239, 1.33878102E+001, 6.66458975E-001, -6.41929097E-001
240, 1.34010465E+001, 6.83940163E-001, -6.21023654E-001
241, 1.34145971E+001, 7.01385710E-001, -6.00290535E-001
242, 1.34284602E+001, 7.18793151E-001, -5.79732671E-001
243, 1.34423472E+001, 7.35813100E-001, -5.59758798E-001
244, 1.34568230E+001, 7.53137833E-001, -5.39556490E-001
245, 1.34716053E+001, 7.70417143E-001, -5.19538024E-001
246, 1.34866919E+001, 7.87648585E-001, -4.99706231E-001
247, 1.35020808E+001, 8.04829723E-001, -4.80063914E-001
248, 1.35177697E+001, 8.21958128E-001, -4.60613852E-001
249, 1.35334338E+001, 8.38690469E-001, -4.41741966E-001
250, 1.35497102E+001, 8.55707326E-001, -4.22680653E-001
251, 1.35662800E+001, 8.72664256E-001, -4.03819708E-001
252, 1.35828006E+001, 8.89221596E-001, -3.85532948E-001
253, 1.35982169E+001, 9.04372663E-001, -3.68912881E-001
254, 1.36135150E+001, 9.19134728E-001, -3.52825017E-001
255, 1.32862135E+001, 5.63233970E-001, -7.46393082E-001
256, 1.32785783E+001, 5.51820755E-001, -7.60818737E-001
257, 1.32706934E+001, 5.40020551E-001, -7.75927776E-001
258, 1.32631776E+001, 5.28759363E-001, -7.90534536E-001
259, 1.32555694E+001, 5.17345900E-001, -8.05529896E-001
260, 1.32480229E+001, 5.06011267E-001, -8.20616012E-001
261, 1.32405387E+001, 4.94755964E-001, -8.35792217E-001
262, 1.32329691E+001, 4.83357799E-001, -8.51364060E-001
263, 1.32256114E+001, 4.72264260E-001, -8.66720193E-001
264, 1.32183168E+001, 4.61251545E-001, -8.82164376E-001
265, 1.32110857E+001, 4.50320142E-001, -8.97695925E-001
266, 1.32040611E+001, 4.39686721E-001, -9.13000944E-001
267, 1.31969566E+001, 4.28917737E-001, -9.28703447E-001
268, 1.31899165E+001, 4.18231495E-001, -9.44491258E-001
269, 1.31829412E+001, 4.07628468E-001, -9.60363677E-001
270, 1.31760308E+001, 3.97109124E-001, -9.76320002E-001
271, 1.31691859E+001, 3.86673929E-001, -9.92359528E-001
272, 1.31624065E+001, 3.76323345E-001, -1.00848155E+000
273, 1.31556931E+001, 3.66057830E-001, -1.02468534E+000
274, 1.31478275E+001, 3.35154167E-001, -1.03491078E+000
275, 1.31461166E+001, 3.06052841E-001, -1.02640182E+000
276, 1.31384277E+001, 2.72659365E-001, -1.03487122E+000
277, 1.31321527E+001, 2.63050099E-001, -1.05034460E+000
278, 1.31259008E+001, 2.53562423E-001, -1.06590210E+000
279, 1.31196723E+001, 2.44196910E-001, -1.08154279E+000
280, 1.31134676E+001, 2.34954124E-001, -1.09726573E+000
281, 1.31072870E+001, 2.25834624E-001, -1.11306996E+000
282, 1.31011310E+001, 2.16838959E-001, -1.12895454E+000
283, 1.30949999E+001, 2.07967672E-001, -1.14491850E+000
284, 1.30888941E+001, 1.99221298E-001, -1.16096088E+000
285, 1.30828139E+001, 1.90600366E-001, -1.17708072E+000
286, 1.30787326E+001, 1.65086922E-001, -1.20786947E+000
287, 1.30728378E+001, 1.57015839E-001, -1.22440710E+000
288, 1.30669795E+001, 1.49280561E-001, -1.24111728E+000
289, 1.30611599E+001, 1.41884066E-001, -1.25799358E+000
290, 1.30553814E+001, 1.34829206E-001, -1.27502949E+000
291, 1.30496461E+001, 1.28118698E-001, -1.29221845E+000
292, 1.30440186E+001, 1.21823164E-001, -1.30936257E+000
293, 1.30383142E+001, 1.15740950E-001, -1.32702898E+000
294, 1.30327219E+001, 1.10078479E-001, -1.34463713E+000
295, 1.30271815E+001, 1.04769898E-001, -1.36237152E+000
296, 1.30433938E+001, 9.38259208E-002, -1.39907230E+000
297, 1.30361063E+001, 8.79839683E-002, -1.42298165E+000
298, 1.30282562E+001, 8.23182895E-002, -1.44903104E+000
299, 1.30199179E+001, 7.70248615E-002, -1.47704001E+000
300, 1.30115795E+001, 7.24927315E-002, -1.50540595E+000
301, 1.30032487E+001, 6.87423979E-002, -1.53411069E+000
302, 1.29960336E+001, 6.61377719E-002, -1.55927270E+000
303, 1.36393332E+001, 9.43410005E-001, -3.26718573E-001
304, 1.36347080E+001, 9.54434580E-001, -3.12358879E-001
305, 1.36059571E+001, 9.41595480E-001, -3.23627048E-001
306, 1.35744681E+001, 9.13576149E-001, -3.41128647E-001
307, 1.35630717E+001, 9.02319242E-001, -3.53302482E-001
308, 1.35517986E+001, 8.91034776E-001, -3.65565320E-001
309, 1.35403136E+001, 8.79380234E-001, -3.78292084E-001
310, 1.35292929E+001, 8.68041863E-001, -3.90733392E-001
311, 1.35183976E+001, 8.56677956E-001, -4.03261494E-001
312, 1.35073039E+001, 8.44943688E-001, -4.16259232E-001
313, 1.34966651E+001, 8.33529999E-001, -4.28961270E-001
314, 1.34858370E+001, 8.21745870E-001, -4.42136628E-001
315, 1.34754571E+001, 8.10285176E-001, -4.55009511E-001
316, 1.34652058E+001, 7.98802356E-001, -4.67965393E-001
317, 1.34547789E+001, 7.86949144E-001, -4.81399880E-001
318, 1.34447904E+001, 7.75423485E-001, -4.94521918E-001
319, 1.34349322E+001, 7.63877757E-001, -5.07724622E-001
320, 1.34249122E+001, 7.51961887E-001, -5.21410956E-001
321, 1.34153204E+001, 7.40377510E-001, -5.34775036E-001
322, 1.34058607E+001, 7.28775132E-001, -5.48217406E-001
323, 1.33962530E+001, 7.16803063E-001, -5.62148168E-001
324, 1.33870631E+001, 7.05166247E-001, -5.75747046E-001
325, 1.33780069E+001, 6.93513508E-001, -5.89421796E-001
326, 1.33688168E+001, 6.81491729E-001, -6.03589435E-001
327, 1.33600338E+001, 6.69808781E-001, -6.17415741E-001
328, 1.33513861E+001, 6.58111998E-001, -6.31315459E-001
329, 1.33426185E+001, 6.46047025E-001, -6.45712296E-001
330, 1.33342471E+001, 6.34324277E-001, -6.59758535E-001
331, 1.33260126E+001, 6.22589789E-001, -6.73875686E-001
332, 1.33176722E+001, 6.10488163E-001, -6.88493919E-001
333, 1.33097171E+001, 5.98731970E-001, -7.02752477E-001
334, 1.33019002E+001, 5.86966137E-001, -7.17079410E-001
335, 1.32939475E+001, 5.58901455E-001, -7.23010372E-001
336, 1.32935946E+001, 5.37957292E-001, -7.12128728E-001
337, 1.32856452E+001, 5.08748867E-001, -7.17585234E-001
338, 1.32780319E+001, 4.96509497E-001, -7.31914211E-001
339, 1.32706274E+001, 4.84606911E-001, -7.46040594E-001
340, 1.32631172E+001, 4.72535182E-001, -7.60564832E-001
341, 1.32556595E+001, 4.60549012E-001, -7.75186702E-001
342, 1.32484085E+001, 4.48896005E-001, -7.89597884E-001
343, 1.32410560E+001, 4.37080844E-001, -8.04410934E-001
344, 1.32339086E+001, 4.25596364E-001, -8.19007968E-001
345, 1.32266625E+001, 4.13954411E-001, -8.34009441E-001
346, 1.32194708E+001, 4.02400799E-001, -8.49105058E-001
347, 1.32124819E+001, 3.91174014E-001, -8.63976717E-001
348, 1.32053987E+001, 3.79796857E-001, -8.79256544E-001
349, 1.31983709E+001, 3.68509663E-001, -8.94628366E-001
350, 1.31915434E+001, 3.57545306E-001, -9.09768380E-001
351, 1.31846261E+001, 3.46437740E-001, -9.25320121E-001
352, 1.31779074E+001, 3.35650285E-001, -9.40634892E-001
353, 1.31711018E+001, 3.24724414E-001, -9.56363657E-001
354, 1.31643533E+001, 3.13891121E-001, -9.72180756E-001
355, 1.31578008E+001, 3.03373724E-001, -9.87753201E-001
356, 1.31511659E+001, 2.92725173E-001, -1.00374291E+000
357, 1.31465371E+001, 2.64295720E-001, -1.03278585E+000
358, 1.31402438E+001, 2.54639115E-001, -1.04830464E+000
359, 1.31339715E+001, 2.45106929E-001, -1.06390861E+000
360, 1.31277206E+001, 2.35699753E-001, -1.07959680E+000
361, 1.31214914E+001, 2.26418169E-001, -1.09536823E+000
362, 1.31152844E+001, 2.17262755E-001, -1.11122192E+000
363, 1.31090999E+001, 2.08234078E-001, -1.12715690E+000
364, 1.31029383E+001, 1.99332697E-001, -1.14317217E+000
365, 1.30968001E+001, 1.90559165E-001, -1.15926673E+000
366, 1.30906855E+001, 1.81914026E-001, -1.17543960E+000
367, 1.31059816E+001, 1.63808355E-001, -1.20875174E+000
368, 1.30978098E+001, 1.52605916E-001, -1.23161676E+000
369, 1.30897150E+001, 1.42090930E-001, -1.25483299E+000
370, 1.30810091E+001, 1.31448386E-001, -1.28045175E+000
371, 1.30724110E+001, 1.21639607E-001, -1.30643712E+000
372, 1.30639294E+001, 1.12674355E-001, -1.33276323E+000
373, 1.30561176E+001, 1.05068184E-001, -1.35764466E+000
374, 1.35989066E+001, 9.37219377E-001, -3.15895522E-001
375, 1.35895008E+001, 9.17779135E-001, -3.15942316E-001
376, 1.35811108E+001, 8.98148136E-001, -3.14570726E-001
377, 1.35700374E+001, 8.86246398E-001, -3.25679331E-001
378, 1.35590810E+001, 8.74326142E-001, -3.36883648E-001
379, 1.35482421E+001, 8.62388080E-001, -3.48183007E-001
380, 1.35371777E+001, 8.50047000E-001, -3.59945834E-001
381, 1.35265799E+001, 8.38074953E-001, -3.71436254E-001
382, 1.35161017E+001, 8.26087269E-001, -3.83019649E-001
383, 1.35057436E+001, 8.14084665E-001, -3.94695327E-001
384, 1.34951782E+001, 8.01679990E-001, -4.06843695E-001
385, 1.34850663E+001, 7.89649276E-001, -4.18704757E-001
386, 1.34750765E+001, 7.77605820E-001, -4.30655968E-001
387, 1.34652093E+001, 7.65550343E-001, -4.42696613E-001
388, 1.34551530E+001, 7.53094135E-001, -4.55218710E-001
389, 1.34455369E+001, 7.41016450E-001, -4.67438882E-001
390, 1.34360452E+001, 7.28928933E-001, -4.79746289E-001
391, 1.34266784E+001, 7.16832305E-001, -4.92140193E-001
392, 1.34171412E+001, 7.04336675E-001, -5.05023844E-001
393, 1.34080302E+001, 6.92223763E-001, -5.17591245E-001
394, 1.33990458E+001, 6.80103936E-001, -5.30242880E-001
395, 1.33901887E+001, 6.67977919E-001, -5.42977994E-001
396, 1.33811797E+001, 6.55455017E-001, -5.56210671E-001
397, 1.33725827E+001, 6.43318655E-001, -5.69113081E-001
398, 1.33641144E+001, 6.31178303E-001, -5.82096645E-001
399, 1.33555085E+001, 6.18642912E-001, -5.95583332E-001
400, 1.33473035E+001, 6.06496688E-001, -6.08729422E-001
401, 1.33392287E+001, 5.94348677E-001, -6.21954296E-001
402, 1.33312847E+001, 5.82199604E-001, -6.35257164E-001
403, 1.33232222E+001, 5.69658283E-001, -6.49070120E-001
404, 1.33155454E+001, 5.57509292E-001, -6.62529033E-001
405, 1.33080008E+001, 5.45361443E-001, -6.76063513E-001
406, 1.33005889E+001, 5.33215462E-001, -6.89672750E-001
407, 1.32941916E+001, 5.01202277E-001, -7.14268918E-001
408, 1.32865856E+001, 4.88886595E-001, -7.28642220E-001
409, 1.32791854E+001, 4.76913051E-001, -7.42813732E-001
410, 1.32716763E+001, 4.64772719E-001, -7.57385801E-001
411, 1.32642168E+001, 4.52721871E-001, -7.72057243E-001
412, 1.32569610E+001, 4.41009356E-001, -7.86518627E-001
413, 1.32496005E+001, 4.29137342E-001, -8.01384624E-001
414, 1.32424425E+001, 4.17601053E-001, -8.16035121E-001
415, 1.32351825E+001, 4.05910147E-001, -8.31092827E-001
416, 1.32279739E+001, 3.94311602E-001, -8.46246303E-001
417, 1.32209655E+001, 3.83044732E-001, -8.61176167E-001
418, 1.32138594E+001, 3.71630649E-001, -8.76516999E-001
419, 1.32068057E+001, 3.60310601E-001, -8.91951382E-001
420, 1.31999499E+001, 3.49318037E-001, -9.07154137E-001
421, 1.31930008E+001, 3.38185728E-001, -9.22771443E-001
422, 1.31862482E+001, 3.27378038E-001, -9.38151851E-001
423, 1.31794050E+001, 3.16435597E-001, -9.53949091E-001
424, 1.31726159E+001, 3.05589888E-001, -9.69836098E-001
425, 1.31660209E+001, 2.95064372E-001, -9.85478359E-001
426, 1.31593397E+001, 2.84411671E-001, -1.00154073E+000
427, 1.31724655E+001, 2.61633270E-001, -1.03769892E+000
428, 1.31642274E+001, 2.49012192E-001, -1.05797003E+000
429, 1.31548613E+001, 2.34837762E-001, -1.08131029E+000
430, 1.31462317E+001, 2.21944748E-001, -1.10309677E+000
431, 1.31369697E+001, 2.08288334E-001, -1.12678480E+000
432, 1.31278985E+001, 1.95098275E-001, -1.15029667E+000
433, 1.31199562E+001, 1.83702707E-001, -1.17114033E+000
434, 1.36048510E+001, 9.23194324E-001, -2.91567130E-001
435, 1.35926329E+001, 8.93797625E-001, -3.07479077E-001
436, 1.35814325E+001, 8.81799591E-001, -3.18682685E-001
437, 1.35703511E+001, 8.69782637E-001, -3.29983804E-001
438, 1.35593891E+001, 8.57747492E-001, -3.41381747E-001
439, 1.35481997E+001, 8.45305812E-001, -3.53248192E-001
440, 1.35374827E+001, 8.33235954E-001, -3.64840767E-001
441, 1.35268873E+001, 8.21150127E-001, -3.76528048E-001
442, 1.35164142E+001, 8.09049065E-001, -3.88309325E-001
443, 1.35057320E+001, 7.96542446E-001, -4.00568477E-001
444, 1.34955091E+001, 7.84412689E-001, -4.12538566E-001
445, 1.34854102E+001, 7.72269930E-001, -4.24600463E-001
446, 1.34751165E+001, 7.59722613E-001, -4.37146974E-001
447, 1.34652718E+001, 7.47555704E-001, -4.49393183E-001
448, 1.34555530E+001, 7.35378032E-001, -4.61728960E-001
449, 1.34459607E+001, 7.23190337E-001, -4.74153556E-001
450, 1.34361924E+001, 7.10599763E-001, -4.87071307E-001
451, 1.34268590E+001, 6.98393982E-001, -4.99674073E-001
452, 1.34176540E+001, 6.86180425E-001, -5.12363352E-001
453, 1.34085777E+001, 6.73959836E-001, -5.25138371E-001
454, 1.33993444E+001, 6.61338444E-001, -5.38414601E-001
455, 1.33905317E+001, 6.49105850E-001, -5.51361472E-001
456, 1.33818495E+001, 6.36868475E-001, -5.64391715E-001
457, 1.33732982E+001, 6.24627064E-001, -5.77504538E-001
458, 1.33646091E+001, 6.11987324E-001, -5.91126129E-001
459, 1.33563257E+001, 5.99740002E-001, -6.04404315E-001
460, 1.33481749E+001, 5.87490899E-001, -6.17762650E-001
461, 1.33401571E+001, 5.75240761E-001, -6.31200321E-001
462, 1.33320207E+001, 5.62595159E-001, -6.45153817E-001
463, 1.33242748E+001, 5.50345209E-001, -6.58750199E-001
464, 1.33166634E+001, 5.38096479E-001, -6.72423428E-001
465, 1.33091870E+001, 5.25849716E-001, -6.86172672E-001
466, 1.33214541E+001, 5.00113566E-001, -7.17398031E-001
467, 1.33110964E+001, 4.83506445E-001, -7.36885061E-001
468, 1.33005204E+001, 4.66549147E-001, -7.57160365E-001
469, 1.32897364E+001, 4.49257905E-001, -7.78239167E-001
470, 1.32799864E+001, 4.33624291E-001, -7.97659022E-001
471, 1.32697191E+001, 4.17160859E-001, -8.18492316E-001
472, 1.32595576E+001, 4.00866697E-001, -8.39509735E-001
473, 1.32490551E+001, 3.84025361E-001, -8.61662835E-001
474, 1.32385226E+001, 3.67135550E-001, -8.84333328E-001
475, 1.32281120E+001, 3.50440934E-001, -9.07203860E-001
476, 1.32176805E+001, 3.33712272E-001, -9.30598399E-001
477, 1.32075188E+001, 3.17415953E-001, -9.53864713E-001
478, 1.31977633E+001, 3.01770564E-001, -9.76660519E-001
479, 1.31884045E+001, 2.86761102E-001, -9.98967864E-001
480, 1.36165618E+001, 9.18946299E-001, -2.84392990E-001
481, 1.36205126E+001, 9.06112219E-001, -2.96174392E-001
482, 1.36222057E+001, 8.91056215E-001, -3.10358860E-001
483, 1.36061478E+001, 8.74083339E-001, -3.26372363E-001
484, 1.35899782E+001, 8.56680088E-001, -3.42953201E-001
485, 1.35740668E+001, 8.39233972E-001, -3.59737562E-001
486, 1.35587607E+001, 8.22136294E-001, -3.76343615E-001
487, 1.35433662E+001, 8.04612134E-001, -3.93523997E-001
488, 1.35279028E+001, 7.86661312E-001, -4.11289657E-001
489, 1.35123907E+001, 7.68283909E-001, -4.29651500E-001
490, 1.34987766E+001, 7.51832594E-001, -4.46237396E-001
491, 1.34857135E+001, 7.35748487E-001, -4.62588044E-001
492, 1.34719458E+001, 7.18462586E-001, -4.80308504E-001
493, 1.34578320E+001, 7.00365689E-001, -4.99024055E-001
494, 1.34446013E+001, 6.83033689E-001, -5.17104929E-001
495, 1.34322193E+001, 6.66471535E-001, -5.34525142E-001
496, 1.34192225E+001, 6.48709070E-001, -5.53362082E-001
497, 1.34076252E+001, 6.32511830E-001, -5.70677884E-001
498, 1.33954398E+001, 6.15117009E-001, -5.89421040E-001
499, 1.33827234E+001, 5.96524383E-001, -6.09622910E-001
500, 1.33716230E+001, 5.79901508E-001, -6.27831334E-001
501, 1.33602622E+001, 5.62480927E-001, -6.47062076E-001
502, 1.33489282E+001, 5.44660163E-001, -6.66891726E-001
503, 1.33383687E+001, 5.27629542E-001, -6.85990601E-001
504, 1.36451623E+001, 9.31625412E-001, -2.72951637E-001
505, 1.36491222E+001, 9.18868074E-001, -2.84662764E-001
506, 1.30083176E+001, 1.47156384E-001, -1.40960401E+000
507, 1.30085206E+001, 1.22518822E-001, -1.40262972E+000
508, 1.30024531E+001, 1.12808195E-001, -1.42070131E+000
509, 1.29896879E+001, 1.09821688E-001, -1.46293730E+000
510, 1.29782252E+001, 9.90294024E-002, -1.49991717E+000
511, 1.29675445E+001, 9.48475271E-002, -1.53597408E+000
512, 1.29595372E+001, 1.20838903E-001, -1.56513232E+000
513, 1.29597806E+001, 1.42604219E-001, -1.56558374E+000
514, 1.29595387E+001, 1.59027007E-001, -1.56732132E+000
515, 1.30106148E+001, 1.72245766E-001, -1.40836775E+000
516, 1.30035903E+001, 1.69091394E-001, -1.42971298E+000
517, 1.29965579E+001, 1.64574212E-001, -1.45078483E+000
518, 1.29898359E+001, 1.59019030E-001, -1.47090814E+000
519, 1.29830595E+001, 1.58025564E-001, -1.49215605E+000
520, 1.29766479E+001, 1.57825087E-001, -1.51245947E+000
521, 1.29703421E+001, 1.56100193E-001, -1.53238512E+000
522, 1.29645217E+001, 1.55952795E-001, -1.55107572E+000
523, 1.29959187E+001, 1.12758003E-001, -1.44266815E+000
524, 1.29839528E+001, 1.03536800E-001, -1.48116286E+000
525, 1.29728728E+001, 9.75712793E-002, -1.51796191E+000
526, 1.29628111E+001, 9.03781727E-002, -1.55200706E+000
527, 1.29586840E+001, 9.67069351E-002, -1.56669299E+000
528, 1.29753992E+001, 1.18449112E-001, -1.51182873E+000
529, 1.30017867E+001, 1.30801605E-001, -1.42713963E+000
530, 1.29863644E+001, 1.32844106E-001, -1.47779261E+000
531, 1.29940469E+001, 1.36288583E-001, -1.45347750E+000
532, 1.29808411E+001, 1.19138612E-001, -1.49387624E+000
533, 1.30007356E+001, 1.49921706E-001, -1.43470973E+000
534, 1.29727544E+001, 1.37849525E-001, -1.52270582E+000
535, 1.29696375E+001, 1.16224146E-001, -1.53080173E+000
536, 1.29639421E+001, 1.09616424E-001, -1.54948530E+000
537, 1.29658707E+001, 1.34723151E-001, -1.54497518E+000
538, 1.29792157E+001, 1.38738153E-001, -1.50184220E+000
539, 1.30739418E+001, 2.26311342E-001, -1.22518510E+000
540, 1.30710796E+001, 1.93062567E-001, -1.21842740E+000
541, 1.30632332E+001, 1.82038915E-001, -1.23997413E+000
542, 1.30504521E+001, 1.64519641E-001, -1.27554666E+000
543, 1.30388056E+001, 1.51344249E-001, -1.30964847E+000
544, 1.30268995E+001, 1.40487831E-001, -1.34591730E+000
545, 1.30234170E+001, 1.82393463E-001, -1.37060314E+000
546, 1.30224821E+001, 1.59744270E-001, -1.36672691E+000
547, 1.30210107E+001, 1.34604754E-001, -1.36389396E+000
548, 1.30677779E+001, 2.27701309E-001, -1.24664362E+000
549, 1.30617136E+001, 2.19268740E-001, -1.26278674E+000
550, 1.30555211E+001, 2.11642357E-001, -1.27954897E+000
551, 1.30488168E+001, 2.04002567E-001, -1.29784909E+000
552, 1.30414727E+001, 1.94438802E-001, -1.31746047E+000
553, 1.30347766E+001, 1.91726352E-001, -1.33767694E+000
554, 1.30288920E+001, 1.90069721E-001, -1.35570255E+000
555, 1.30565319E+001, 1.73276340E-001, -1.25876603E+000
556, 1.30446847E+001, 1.56406529E-001, -1.29171530E+000
557, 1.30326622E+001, 1.46143148E-001, -1.32843619E+000
558, 1.30359587E+001, 1.70659060E-001, -1.32636603E+000
559, 1.30470683E+001, 1.80791614E-001, -1.29395555E+000
560, 1.30595395E+001, 1.97318059E-001, -1.25985525E+000
561, 1.30532027E+001, 1.89049717E-001, -1.27722274E+000
562, 1.30292165E+001, 1.68810070E-001, -1.34765995E+000
563, 1.30665566E+001, 2.07161580E-001, -1.24087483E+000
564, 1.30416088E+001, 1.71284735E-001, -1.30810037E+000
565, 1.29366963E+001, 1.41628332E-001, -1.64320405E+000
566, 1.29482021E+001, 1.19007284E-001, -1.60349485E+000
567, 1.29499287E+001, 1.41316018E-001, -1.59735406E+000
568, 1.29503002E+001, 9.75793588E-002, -1.59637631E+000
569, 1.29335530E+001, 1.05031912E-001, -1.65435513E+000
570, 1.29432299E+001, 1.38382196E-001, -1.62058719E+000
571, 1.29299261E+001, 1.31774051E-001, -1.66673350E+000
572, 1.29459725E+001, 1.54758622E-001, -1.61096798E+000
573, 1.29505688E+001, 1.57966109E-001, -1.59501831E+000
574, 1.29426854E+001, 1.01586677E-001, -1.62273423E+000
575, 1.29389419E+001, 1.21596545E-001, -1.63556450E+000
576, 1.35983600E+001, 9.20282260E-001, -3.49061692E-001
577, 1.31396899E+001, 2.95589370E-001, -1.04185062E+000
578, 1.31284006E+001, 2.69989853E-001, -1.06574246E+000
579, 1.31162992E+001, 2.55729272E-001, -1.09804465E+000
580, 1.31038884E+001, 2.35875972E-001, -1.12917787E+000
581, 1.30916406E+001, 2.22997525E-001, -1.16362828E+000
582, 1.30883459E+001, 2.45889495E-001, -1.18605689E+000
583, 1.30853055E+001, 2.16944866E-001, -1.18188747E+000
584, 1.31330650E+001, 3.09959560E-001, -1.06991686E+000
585, 1.31257564E+001, 3.05040285E-001, -1.09105986E+000
586, 1.31194849E+001, 2.99926502E-001, -1.10894924E+000
587, 1.31136715E+001, 2.88516936E-001, -1.12246670E+000
588, 1.31066843E+001, 2.75731928E-001, -1.13932569E+000
589, 1.30999254E+001, 2.69021401E-001, -1.15856383E+000
590, 1.30938857E+001, 2.62178000E-001, -1.17546930E+000
591, 1.31407884E+001, 3.23047323E-001, -1.05151071E+000
592, 1.31335862E+001, 2.83510711E-001, -1.05557568E+000
593, 1.31226923E+001, 2.65777821E-001, -1.08212857E+000
594, 1.31104677E+001, 2.45528138E-001, -1.11218466E+000
595, 1.30980741E+001, 2.29099548E-001, -1.14515967E+000
596, 1.31013990E+001, 2.52019781E-001, -1.14531049E+000
597, 1.31127017E+001, 2.68865621E-001, -1.11614245E+000
598, 1.30952983E+001, 2.45887011E-001, -1.16267096E+000
599, 1.31070340E+001, 2.56033439E-001, -1.12858268E+000
600, 1.31196738E+001, 2.81427777E-001, -1.09943043E+000
601, 1.31272889E+001, 2.87701072E-001, -1.07780760E+000
602, 1.32876717E+001, 5.24754650E-001, -7.21151488E-001
603, 1.32734012E+001, 5.06499932E-001, -7.50678941E-001
604, 1.32580922E+001, 4.82625045E-001, -7.80341768E-001
605, 1.32436665E+001, 4.59551540E-001, -8.08668156E-001
606, 1.32286284E+001, 4.37953691E-001, -8.40581083E-001
607, 1.32146631E+001, 4.11960322E-001, -8.68251615E-001
608, 1.32004019E+001, 3.91225588E-001, -9.00431745E-001
609, 1.31864088E+001, 3.69007391E-001, -9.31931756E-001
610, 1.31731183E+001, 3.45835922E-001, -9.61557132E-001
611, 1.31602519E+001, 3.25933071E-001, -9.91872330E-001
612, 1.31555837E+001, 3.43192169E-001, -1.01464827E+000
613, 1.31530631E+001, 3.16196387E-001, -1.00958409E+000
614, 1.32764889E+001, 5.30880185E-001, -7.55486765E-001
615, 1.32682496E+001, 5.18776682E-001, -7.71575015E-001
616, 1.32604714E+001, 5.06873476E-001, -7.86637390E-001
617, 1.32532343E+001, 4.95766154E-001, -8.00798151E-001
618, 1.32455421E+001, 4.83926161E-001, -8.16065676E-001
619, 1.32381884E+001, 4.73306683E-001, -8.31301892E-001
620, 1.32305501E+001, 4.61586514E-001, -8.47083711E-001
621, 1.32230569E+001, 4.50143053E-001, -8.62894233E-001
622, 1.32158360E+001, 4.37925682E-001, -8.77811040E-001
623, 1.32085312E+001, 4.33660871E-001, -8.97202371E-001
624, 1.32026325E+001, 4.17316944E-001, -9.06637662E-001
625, 1.31950447E+001, 4.06382841E-001, -9.24019171E-001
626, 1.31882189E+001, 3.95447436E-001, -9.39331651E-001
627, 1.31808305E+001, 3.83496906E-001, -9.56066407E-001
628, 1.31731542E+001, 3.71127019E-001, -9.73671882E-001
629, 1.31666534E+001, 3.69320948E-001, -9.92875841E-001
630, 1.31609759E+001, 3.59817682E-001, -1.00588333E+000
631, 1.32853286E+001, 5.41691873E-001, -7.37119789E-001
632, 1.32655543E+001, 4.95375447E-001, -7.66419368E-001
633, 1.32808667E+001, 5.17081909E-001, -7.35783773E-001
634, 1.32509636E+001, 4.70723598E-001, -7.93962280E-001
635, 1.32359892E+001, 4.48288256E-001, -8.24693700E-001
636, 1.32213097E+001, 4.26189472E-001, -8.55887945E-001
637, 1.32076955E+001, 4.00227474E-001, -8.83064323E-001
638, 1.31933409E+001, 3.81270125E-001, -9.16836967E-001
639, 1.31797121E+001, 3.57359813E-001, -9.46800863E-001
640, 1.31668987E+001, 3.31599842E-001, -9.73952525E-001
641, 1.32100466E+001, 4.19981902E-001, -8.85910705E-001
642, 1.31653071E+001, 3.49287626E-001, -9.87399355E-001
643, 1.35211355E+001, 8.44470556E-001, -3.89281339E-001
644, 1.35112434E+001, 8.34228673E-001, -4.00786359E-001
645, 1.35015498E+001, 8.23604727E-001, -4.11851913E-001
646, 1.34803339E+001, 8.00775016E-001, -4.37612291E-001
647, 1.34600563E+001, 7.76386828E-001, -4.62000008E-001
648, 1.34403218E+001, 7.51985807E-001, -4.87179291E-001
649, 1.34208748E+001, 7.28446117E-001, -5.14229134E-001
650, 1.34030335E+001, 6.97690106E-001, -5.34440972E-001
651, 1.33846032E+001, 6.80994540E-001, -5.67366928E-001
652, 1.33682394E+001, 6.48744439E-001, -5.86608503E-001
653, 1.33526443E+001, 6.27130906E-001, -6.12242603E-001
654, 1.33361436E+001, 6.02307808E-001, -6.39339271E-001
655, 1.33193560E+001, 5.78002752E-001, -6.68199603E-001
656, 1.33018996E+001, 5.51777097E-001, -6.98323003E-001
657, 1.33013915E+001, 5.70191832E-001, -7.10206320E-001
658, 1.34023010E+001, 7.11503799E-001, -5.45599874E-001
659, 1.33939445E+001, 6.93596308E-001, -5.53270933E-001
660, 1.33652132E+001, 6.59921434E-001, -6.01323804E-001
661, 1.33567695E+001, 6.49112032E-001, -6.15581134E-001
662, 1.33480504E+001, 6.36880575E-001, -6.29982884E-001
663, 1.33398089E+001, 6.25280853E-001, -6.43858249E-001
664, 1.33317330E+001, 6.13308653E-001, -6.57294711E-001
665, 1.33232228E+001, 6.01095431E-001, -6.71878355E-001
666, 1.33152389E+001, 5.90378332E-001, -6.86139529E-001
667, 1.33079444E+001, 5.82678301E-001, -7.00483072E-001
668, 1.34305801E+001, 7.40309336E-001, -5.00578530E-001
669, 1.34502377E+001, 7.65133401E-001, -4.74941561E-001
670, 1.34906094E+001, 8.11795223E-001, -4.24897379E-001
671, 1.34701380E+001, 7.88669393E-001, -4.49749412E-001
672, 1.34110518E+001, 7.15289332E-001, -5.27728884E-001
673, 1.33752702E+001, 6.68059636E-001, -5.81691703E-001
674, 1.33604408E+001, 6.37989423E-001, -5.99288906E-001
675, 1.33440399E+001, 6.14469790E-001, -6.26436075E-001
676, 1.33280323E+001, 5.90481879E-001, -6.53157136E-001
677, 1.33102970E+001, 5.66576301E-001, -6.85016400E-001
**
** Elements ++++++++++++++++++++++++++++++++++++++++++++++++
**
*Element, Type=S3, Elset=Shell_part-1
1, 1, 2, 68
2, 2, 54, 68
3, 67, 55, 56
4, 56, 57, 66
5, 481, 480, 52
6, 65, 59, 64
7, 61, 62, 63
8, 62, 3, 4
9, 4, 63, 62
10, 63, 64, 61
11, 60, 64, 59
12, 66, 67, 56
13, 61, 64, 60
14, 66, 57, 65
15, 504, 53, 505
16, 57, 58, 65
17, 58, 59, 65
18, 51, 504, 505
19, 67, 68, 55
20, 68, 54, 55
21, 505, 52, 480
22, 5, 6, 83
23, 6, 69, 83
24, 70, 71, 82
25, 71, 72, 81
26, 73, 74, 80
27, 74, 75, 79
28, 76, 77, 78
29, 77, 2, 1
30, 1, 78, 77
31, 78, 79, 76
32, 79, 80, 74
33, 80, 81, 73
34, 81, 82, 71
35, 82, 83, 70
36, 83, 69, 70
37, 81, 72, 73
38, 75, 76, 79
39, 89, 90, 60
40, 91, 92, 62
41, 8, 3, 92
42, 54, 2, 7
43, 55, 54, 84
44, 56, 55, 85
45, 57, 56, 86
46, 58, 57, 87
47, 59, 58, 88
48, 60, 59, 89
49, 61, 60, 90
50, 62, 61, 91
51, 3, 62, 92
52, 55, 84, 85
53, 61, 90, 91
54, 86, 56, 85
55, 87, 57, 86
56, 88, 58, 87
57, 54, 7, 84
58, 59, 88, 89
59, 9, 10, 94
60, 10, 93, 94
61, 93, 4, 3
62, 3, 94, 93
63, 11, 12, 110
64, 12, 95, 110
65, 95, 96, 109
66, 96, 97, 108
67, 97, 98, 108
68, 98, 99, 107
69, 99, 100, 106
70, 101, 102, 105
71, 102, 103, 104
72, 103, 6, 5
73, 5, 104, 103
74, 104, 105, 102
75, 105, 106, 100
76, 106, 107, 99
77, 107, 108, 98
78, 108, 109, 96
79, 109, 110, 95
80, 101, 105, 100
81, 13, 111, 69
82, 111, 112, 70
83, 112, 113, 71
84, 113, 114, 72
85, 114, 115, 73
86, 115, 116, 74
87, 116, 117, 75
88, 117, 118, 76
89, 118, 119, 77
90, 119, 7, 2
91, 69, 6, 13
92, 70, 69, 111
93, 71, 70, 112
94, 72, 71, 113
95, 73, 72, 114
96, 74, 73, 115
97, 75, 74, 116
98, 76, 75, 117
99, 77, 76, 118
100, 2, 77, 119
101, 7, 120, 84
102, 121, 122, 506
103, 122, 14, 507
104, 506, 122, 507
105, 14, 123, 507
106, 124, 508, 123
107, 124, 125, 508
108, 126, 127, 509
109, 128, 129, 510
110, 130, 131, 511
111, 133, 134, 512
112, 134, 17, 513
113, 17, 8, 514
114, 513, 17, 514
115, 8, 92, 514
116, 85, 84, 515
117, 86, 85, 516
118, 85, 515, 516
119, 87, 86, 517
120, 86, 516, 517
121, 88, 87, 518
122, 87, 517, 518
123, 89, 88, 519
124, 90, 89, 520
125, 89, 519, 520
126, 91, 90, 521
127, 90, 520, 521
128, 92, 91, 522
129, 514, 92, 522
130, 91, 521, 522
131, 84, 120, 515
132, 120, 121, 515
133, 507, 123, 508
134, 125, 126, 523
135, 127, 128, 524
136, 129, 130, 525
137, 131, 132, 526
138, 132, 15, 16
139, 16, 133, 527
140, 134, 513, 512
141, 121, 506, 515
142, 88, 518, 519
143, 525, 130, 511
144, 125, 523, 508
145, 511, 131, 526
146, 524, 128, 510
147, 523, 126, 509
148, 127, 524, 509
149, 129, 525, 510
150, 132, 16, 527
151, 527, 133, 512
152, 132, 527, 526
153, 510, 525, 528
154, 506, 507, 529
155, 507, 508, 529
156, 509, 524, 530
157, 523, 509, 531
158, 509, 530, 531
159, 508, 523, 529
160, 524, 510, 532
161, 530, 524, 532
162, 510, 528, 532
163, 517, 516, 533
164, 518, 517, 531
165, 521, 520, 534
166, 515, 506, 516
167, 519, 518, 530
168, 528, 525, 535
169, 525, 511, 535
170, 511, 526, 536
171, 523, 531, 529
172, 535, 511, 536
173, 527, 512, 536
174, 512, 513, 537
175, 513, 514, 522
176, 519, 530, 538
177, 520, 519, 538
178, 530, 532, 538
179, 518, 531, 530
180, 521, 534, 537
181, 520, 538, 534
182, 516, 506, 533
183, 522, 521, 537
184, 537, 513, 522
185, 533, 506, 529
186, 536, 512, 537
187, 531, 517, 533
188, 526, 527, 536
189, 531, 533, 529
190, 532, 528, 538
191, 535, 536, 537
192, 535, 537, 534
193, 535, 534, 528
194, 534, 538, 528
195, 3, 8, 94
196, 135, 18, 9
197, 9, 94, 135
198, 94, 8, 135
199, 166, 167, 136
200, 137, 165, 136
201, 137, 138, 164
202, 162, 163, 139
203, 140, 161, 139
204, 140, 141, 160
205, 141, 142, 158
206, 156, 157, 143
207, 144, 155, 143
208, 144, 145, 154
209, 145, 146, 152
210, 150, 151, 147
211, 148, 149, 147
212, 148, 19, 20
213, 166, 136, 165
214, 164, 138, 163
215, 138, 139, 163
216, 160, 141, 159
217, 141, 158, 159
218, 154, 145, 153
219, 145, 152, 153
220, 146, 147, 151
221, 165, 137, 164
222, 146, 151, 152
223, 20, 149, 148
224, 154, 155, 144
225, 157, 158, 142
226, 160, 161, 140
227, 167, 12, 11
228, 150, 147, 149
229, 162, 139, 161
230, 142, 143, 157
231, 156, 143, 155
232, 11, 136, 167
233, 13, 6, 176
234, 95, 12, 21
235, 96, 95, 168
236, 97, 96, 169
237, 98, 97, 170
238, 99, 98, 171
239, 100, 99, 172
240, 101, 100, 173
241, 102, 101, 174
242, 103, 102, 175
243, 6, 103, 176
244, 96, 168, 169
245, 21, 168, 95
246, 169, 170, 97
247, 170, 171, 98
248, 171, 172, 99
249, 172, 173, 100
250, 173, 174, 101
251, 174, 175, 102
252, 175, 176, 103
253, 13, 177, 111
254, 177, 178, 539
255, 178, 22, 540
256, 539, 178, 540
257, 22, 179, 540
258, 179, 180, 540
259, 180, 181, 541
260, 182, 183, 542
261, 184, 185, 543
262, 186, 187, 544
263, 188, 14, 122
264, 120, 7, 545
265, 7, 119, 545
266, 121, 120, 546
267, 120, 545, 546
268, 122, 121, 547
269, 188, 122, 547
270, 121, 546, 547
271, 113, 112, 548
272, 114, 113, 549
273, 113, 548, 549
274, 115, 114, 550
275, 114, 549, 550
276, 116, 115, 551
277, 117, 116, 552
278, 116, 551, 552
279, 118, 117, 553
280, 117, 552, 553
281, 119, 118, 554
282, 545, 119, 554
283, 118, 553, 554
284, 111, 177, 539
285, 540, 180, 541
286, 181, 182, 555
287, 183, 184, 556
288, 185, 186, 557
289, 187, 188, 547
290, 557, 186, 544
291, 112, 111, 539
292, 551, 115, 550
293, 556, 184, 543
294, 181, 555, 541
295, 544, 187, 547
296, 555, 182, 542
297, 183, 556, 542
298, 185, 557, 543
299, 543, 557, 558
300, 544, 547, 546
301, 542, 556, 559
302, 541, 555, 560
303, 112, 539, 548
304, 555, 542, 561
305, 560, 555, 561
306, 542, 559, 561
307, 546, 545, 562
308, 545, 554, 562
309, 549, 548, 563
310, 548, 539, 563
311, 557, 544, 562
312, 540, 541, 563
313, 551, 550, 561
314, 550, 549, 560
315, 553, 552, 558
316, 552, 551, 559
317, 544, 546, 562
318, 539, 540, 563
319, 561, 550, 560
320, 541, 560, 563
321, 557, 562, 558
322, 551, 561, 559
323, 553, 558, 562
324, 549, 563, 560
325, 559, 564, 552
326, 554, 553, 562
327, 556, 543, 564
328, 543, 558, 564
329, 559, 556, 564
330, 558, 552, 564
331, 23, 189, 14
332, 189, 190, 123
333, 190, 191, 124
334, 191, 192, 125
335, 192, 193, 126
336, 193, 194, 127
337, 194, 195, 128
338, 195, 196, 129
339, 196, 197, 130
340, 197, 198, 131
341, 198, 24, 132
342, 24, 15, 132
343, 189, 123, 14
344, 190, 124, 123
345, 191, 125, 124
346, 192, 126, 125
347, 193, 127, 126
348, 194, 128, 127
349, 195, 129, 128
350, 196, 130, 129
351, 197, 131, 130
352, 198, 132, 131
353, 25, 199, 204
354, 200, 571, 26
355, 201, 27, 565
356, 134, 133, 566
357, 17, 134, 567
358, 16, 15, 29
359, 15, 28, 29
360, 29, 202, 568
361, 203, 204, 569
362, 204, 199, 569
363, 566, 133, 568
364, 565, 27, 570
365, 201, 565, 200
366, 134, 566, 567
367, 27, 18, 572
368, 570, 27, 572
369, 18, 135, 572
370, 135, 8, 573
371, 572, 135, 573
372, 8, 17, 573
373, 133, 16, 568
374, 568, 202, 574
375, 566, 568, 574
376, 202, 203, 574
377, 203, 569, 574
378, 199, 26, 571
379, 571, 200, 565
380, 199, 571, 569
381, 571, 565, 575
382, 569, 571, 575
383, 565, 570, 575
384, 574, 569, 575
385, 566, 574, 575
386, 570, 572, 567
387, 570, 567, 566
388, 570, 566, 575
389, 572, 573, 567
390, 17, 567, 573
391, 16, 29, 568
392, 30, 205, 254
393, 205, 31, 576
394, 254, 205, 576
395, 31, 206, 576
396, 206, 207, 253
397, 207, 208, 252
398, 208, 209, 252
399, 209, 210, 251
400, 210, 211, 250
401, 211, 212, 250
402, 212, 213, 249
403, 213, 214, 248
404, 214, 215, 248
405, 215, 216, 247
406, 216, 217, 246
407, 217, 218, 246
408, 218, 219, 245
409, 219, 220, 244
410, 220, 221, 244
411, 221, 222, 243
412, 222, 223, 242
413, 223, 224, 242
414, 224, 225, 241
415, 225, 226, 240
416, 226, 227, 240
417, 227, 228, 239
418, 228, 229, 238
419, 229, 230, 238
420, 230, 231, 237
421, 231, 232, 236
422, 232, 233, 236
423, 233, 234, 235
424, 234, 20, 19
425, 19, 235, 234
426, 235, 236, 233
427, 236, 237, 231
428, 237, 238, 230
429, 238, 239, 228
430, 239, 240, 227
431, 240, 241, 225
432, 241, 242, 224
433, 242, 243, 222
434, 243, 244, 221
435, 244, 245, 219
436, 245, 246, 218
437, 246, 247, 216
438, 247, 248, 215
439, 248, 249, 213
440, 249, 250, 212
441, 250, 251, 210
442, 251, 252, 209
443, 252, 253, 207
444, 206, 253, 576
445, 576, 253, 254
446, 255, 256, 150
447, 256, 257, 151
448, 257, 258, 152
449, 269, 270, 164
450, 270, 271, 165
451, 271, 272, 166
452, 272, 273, 167
453, 273, 21, 12
454, 150, 149, 255
455, 151, 150, 256
456, 152, 151, 257
457, 153, 152, 258
458, 154, 153, 259
459, 155, 154, 260
460, 156, 155, 261
461, 157, 156, 262
462, 158, 157, 263
463, 159, 158, 264
464, 160, 159, 265
465, 161, 160, 266
466, 162, 161, 267
467, 163, 162, 268
468, 164, 163, 269
469, 20, 32, 149
470, 265, 159, 264
471, 263, 157, 262
472, 260, 154, 259
473, 164, 270, 165
474, 165, 271, 166
475, 166, 272, 167
476, 167, 273, 12
477, 268, 162, 267
478, 262, 156, 261
479, 153, 258, 259
480, 267, 161, 266
481, 255, 149, 32
482, 266, 160, 265
483, 264, 158, 263
484, 261, 155, 260
485, 163, 268, 269
486, 21, 274, 168
487, 275, 33, 577
488, 33, 276, 577
489, 277, 278, 578
490, 279, 280, 579
491, 281, 282, 580
492, 283, 284, 581
493, 285, 22, 178
494, 177, 13, 582
495, 13, 176, 582
496, 178, 177, 583
497, 285, 178, 583
498, 177, 582, 583
499, 170, 169, 584
500, 171, 170, 585
501, 170, 584, 585
502, 172, 171, 586
503, 171, 585, 586
504, 173, 172, 587
505, 172, 586, 587
506, 174, 173, 588
507, 173, 587, 588
508, 175, 174, 589
509, 174, 588, 589
510, 176, 175, 590
511, 582, 176, 590
512, 175, 589, 590
513, 168, 274, 591
514, 577, 276, 592
515, 276, 277, 592
516, 274, 275, 591
517, 578, 278, 593
518, 278, 279, 593
519, 277, 578, 592
520, 591, 275, 577
521, 279, 579, 593
522, 280, 281, 594
523, 282, 283, 595
524, 584, 169, 591
525, 284, 285, 583
526, 169, 168, 591
527, 579, 280, 594
528, 580, 282, 595
529, 581, 284, 583
530, 595, 283, 581
531, 594, 281, 580
532, 580, 595, 596
533, 579, 594, 597
534, 583, 582, 581
535, 595, 581, 598
536, 598, 581, 582
537, 594, 580, 599
538, 597, 594, 599
539, 580, 596, 599
540, 591, 577, 584
541, 593, 579, 600
542, 579, 597, 600
543, 586, 585, 600
544, 587, 586, 600
545, 588, 587, 597
546, 589, 588, 596
547, 584, 592, 601
548, 585, 584, 601
549, 592, 578, 601
550, 595, 598, 596
551, 592, 584, 577
552, 578, 593, 601
553, 582, 590, 598
554, 600, 585, 601
555, 587, 600, 597
556, 589, 596, 598
557, 601, 593, 600
558, 588, 597, 599
559, 596, 588, 599
560, 589, 598, 590
561, 34, 286, 22
562, 286, 287, 179
563, 287, 288, 180
564, 288, 289, 181
565, 289, 290, 182
566, 290, 291, 183
567, 291, 292, 184
568, 292, 293, 185
569, 293, 294, 186
570, 294, 295, 187
571, 295, 23, 188
572, 23, 14, 188
573, 286, 179, 22
574, 287, 180, 179
575, 288, 181, 180
576, 289, 182, 181
577, 290, 183, 182
578, 291, 184, 183
579, 292, 185, 184
580, 293, 186, 185
581, 294, 187, 186
582, 295, 188, 187
583, 23, 35, 296
584, 296, 297, 189
585, 297, 298, 191
586, 193, 192, 299
587, 300, 194, 299
588, 300, 301, 195
589, 301, 302, 197
590, 302, 36, 198
591, 36, 24, 198
592, 189, 23, 296
593, 198, 197, 302
594, 189, 297, 190
595, 297, 191, 190
596, 195, 301, 196
597, 301, 197, 196
598, 192, 191, 298
599, 195, 194, 300
600, 298, 299, 192
601, 193, 299, 194
602, 15, 24, 37
603, 28, 15, 37
604, 30, 303, 305
605, 303, 38, 304
606, 304, 39, 303
607, 305, 31, 205
608, 205, 30, 305
609, 305, 303, 39
610, 32, 20, 334
611, 206, 31, 40
612, 207, 206, 306
613, 208, 207, 307
614, 209, 208, 308
615, 210, 209, 309
616, 211, 210, 310
617, 212, 211, 311
618, 213, 212, 312
619, 214, 213, 313
620, 215, 214, 314
621, 216, 215, 315
622, 217, 216, 316
623, 218, 217, 317
624, 219, 218, 318
625, 220, 219, 319
626, 221, 220, 320
627, 222, 221, 321
628, 223, 222, 322
629, 224, 223, 323
630, 225, 224, 324
631, 226, 225, 325
632, 227, 226, 326
633, 228, 227, 327
634, 229, 228, 328
635, 230, 229, 329
636, 231, 230, 330
637, 232, 231, 331
638, 233, 232, 332
639, 234, 233, 333
640, 20, 234, 334
641, 207, 306, 307
642, 206, 40, 306
643, 308, 208, 307
644, 309, 209, 308
645, 310, 210, 309
646, 311, 211, 310
647, 312, 212, 311
648, 313, 213, 312
649, 314, 214, 313
650, 315, 215, 314
651, 316, 216, 315
652, 317, 217, 316
653, 318, 218, 317
654, 319, 219, 318
655, 320, 220, 319
656, 321, 221, 320
657, 322, 222, 321
658, 323, 223, 322
659, 324, 224, 323
660, 325, 225, 324
661, 326, 226, 325
662, 327, 227, 326
663, 328, 228, 327
664, 329, 229, 328
665, 330, 230, 329
666, 331, 231, 330
667, 332, 232, 331
668, 333, 233, 332
669, 234, 333, 334
670, 32, 335, 255
671, 336, 41, 602
672, 41, 337, 602
673, 338, 339, 603
674, 340, 341, 604
675, 342, 343, 605
676, 344, 345, 606
677, 346, 347, 607
678, 348, 349, 608
679, 350, 351, 609
680, 352, 353, 610
681, 354, 355, 611
682, 356, 33, 275
683, 274, 21, 612
684, 21, 273, 612
685, 275, 274, 613
686, 356, 275, 613
687, 274, 612, 613
688, 257, 256, 614
689, 258, 257, 615
690, 257, 614, 615
691, 259, 258, 616
692, 258, 615, 616
693, 260, 259, 617
694, 259, 616, 617
695, 261, 260, 618
696, 260, 617, 618
697, 262, 261, 619
698, 263, 262, 620
699, 262, 619, 620
700, 264, 263, 621
701, 263, 620, 621
702, 265, 264, 622
703, 264, 621, 622
704, 266, 265, 623
705, 267, 266, 624
706, 266, 623, 624
707, 268, 267, 625
708, 267, 624, 625
709, 269, 268, 626
710, 268, 625, 626
711, 270, 269, 627
712, 269, 626, 627
713, 271, 270, 628
714, 270, 627, 628
715, 272, 271, 629
716, 271, 628, 629
717, 273, 272, 630
718, 612, 273, 630
719, 272, 629, 630
720, 255, 335, 631
721, 335, 336, 631
722, 603, 339, 632
723, 339, 340, 632
724, 337, 338, 633
725, 340, 604, 632
726, 337, 633, 602
727, 341, 342, 634
728, 343, 344, 635
729, 345, 346, 636
730, 347, 348, 637
731, 349, 350, 638
732, 351, 352, 639
733, 353, 354, 640
734, 614, 256, 631
735, 355, 356, 613
736, 261, 618, 619
737, 336, 602, 631
738, 256, 255, 631
739, 265, 622, 623
740, 636, 346, 607
741, 604, 341, 634
742, 605, 343, 635
743, 606, 345, 636
744, 607, 347, 637
745, 608, 349, 638
746, 609, 351, 639
747, 610, 353, 640
748, 611, 355, 613
749, 637, 348, 608
750, 638, 350, 609
751, 639, 352, 610
752, 640, 354, 611
753, 633, 338, 603
754, 635, 344, 606
755, 634, 342, 605
756, 605, 635, 619
757, 635, 606, 620
758, 632, 604, 616
759, 620, 606, 621
760, 619, 635, 620
761, 605, 619, 618
762, 606, 636, 621
763, 634, 605, 618
764, 607, 637, 641
765, 604, 634, 617
766, 608, 638, 625
767, 638, 609, 626
768, 613, 612, 611
769, 640, 611, 642
770, 642, 611, 612
771, 633, 603, 614
772, 637, 608, 624
773, 603, 632, 615
774, 615, 614, 603
775, 616, 615, 632
776, 617, 616, 604
777, 618, 617, 634
778, 622, 621, 636
779, 636, 607, 622
780, 625, 624, 608
781, 626, 625, 638
782, 627, 626, 609
783, 628, 627, 639
784, 627, 609, 639
785, 639, 610, 628
786, 602, 633, 631
787, 642, 612, 630
788, 637, 624, 641
789, 614, 631, 633
790, 622, 607, 641
791, 624, 623, 641
792, 623, 622, 641
793, 630, 629, 642
794, 610, 640, 642
795, 628, 642, 629
796, 642, 628, 610
797, 42, 357, 33
798, 357, 358, 276
799, 358, 359, 277
800, 359, 360, 278
801, 360, 361, 279
802, 361, 362, 280
803, 362, 363, 281
804, 363, 364, 282
805, 364, 365, 283
806, 365, 366, 284
807, 366, 34, 285
808, 34, 22, 285
809, 357, 276, 33
810, 358, 277, 276
811, 359, 278, 277
812, 360, 279, 278
813, 361, 280, 279
814, 362, 281, 280
815, 363, 282, 281
816, 364, 283, 282
817, 365, 284, 283
818, 366, 285, 284
819, 368, 369, 288
820, 370, 371, 291
821, 293, 292, 372
822, 373, 294, 372
823, 373, 35, 295
824, 35, 23, 295
825, 368, 288, 287
826, 370, 289, 369
827, 34, 43, 367
828, 286, 34, 367
829, 49, 480, 481
830, 287, 286, 368
831, 370, 291, 290
832, 293, 372, 294
833, 294, 373, 295
834, 370, 290, 289
835, 367, 368, 286
836, 292, 291, 371
837, 371, 372, 292
838, 288, 369, 289
839, 480, 51, 505
840, 40, 31, 305
841, 305, 39, 44
842, 305, 44, 374
843, 374, 40, 305
844, 375, 45, 376
845, 376, 377, 306
846, 377, 378, 307
847, 378, 379, 308
848, 379, 380, 309
849, 381, 382, 643
850, 382, 383, 644
851, 383, 384, 645
852, 385, 386, 646
853, 387, 388, 647
854, 389, 390, 648
855, 391, 392, 649
856, 393, 394, 650
857, 395, 396, 651
858, 397, 398, 652
859, 399, 400, 653
860, 401, 402, 654
861, 403, 404, 655
862, 405, 406, 656
863, 406, 41, 336
864, 335, 32, 657
865, 32, 334, 657
866, 307, 306, 377
867, 308, 307, 378
868, 309, 308, 379
869, 311, 310, 643
870, 312, 311, 644
871, 313, 312, 645
872, 315, 314, 646
873, 317, 316, 647
874, 319, 318, 648
875, 321, 320, 649
876, 323, 322, 658
877, 324, 323, 659
878, 323, 658, 659
879, 325, 324, 651
880, 327, 326, 660
881, 328, 327, 661
882, 327, 660, 661
883, 329, 328, 662
884, 328, 661, 662
885, 330, 329, 663
886, 329, 662, 663
887, 331, 330, 664
888, 330, 663, 664
889, 332, 331, 665
890, 331, 664, 665
891, 333, 332, 666
892, 332, 665, 666
893, 334, 333, 667
894, 657, 334, 667
895, 333, 666, 667
896, 309, 380, 310
897, 406, 336, 656
898, 649, 320, 668
899, 391, 649, 668
900, 320, 319, 668
901, 40, 375, 306
902, 648, 318, 669
903, 389, 648, 669
904, 318, 317, 669
905, 645, 312, 644
906, 311, 643, 644
907, 380, 381, 310
908, 382, 644, 643
909, 383, 645, 644
910, 385, 646, 670
911, 384, 385, 670
912, 646, 314, 670
913, 387, 647, 671
914, 386, 387, 671
915, 647, 316, 671
916, 388, 389, 669
917, 390, 391, 668
918, 392, 393, 672
919, 395, 651, 659
920, 394, 395, 659
921, 396, 397, 673
922, 398, 399, 674
923, 400, 401, 675
924, 402, 403, 676
925, 404, 405, 677
926, 668, 319, 648
927, 336, 335, 656
928, 335, 657, 656
929, 390, 668, 648
930, 658, 322, 672
931, 388, 669, 647
932, 669, 317, 647
933, 677, 405, 656
934, 676, 403, 655
935, 671, 316, 315
936, 675, 401, 654
937, 674, 399, 653
938, 396, 673, 651
939, 673, 397, 652
940, 398, 674, 652
941, 400, 675, 653
942, 402, 676, 654
943, 671, 315, 646
944, 404, 677, 655
945, 672, 322, 321
946, 313, 645, 670
947, 314, 313, 670
948, 321, 649, 672
949, 325, 651, 673
950, 324, 659, 651
951, 326, 325, 673
952, 386, 671, 646
953, 384, 670, 645
954, 649, 392, 672
955, 376, 306, 375
956, 381, 643, 310
957, 672, 393, 650
958, 394, 659, 650
959, 661, 660, 674
960, 674, 653, 661
961, 676, 655, 665
962, 660, 326, 673
963, 677, 656, 657
964, 672, 650, 658
965, 658, 650, 659
966, 655, 677, 666
967, 675, 654, 663
968, 662, 661, 653
969, 663, 662, 675
970, 664, 663, 654
971, 665, 664, 676
972, 666, 665, 655
973, 652, 674, 660
974, 673, 652, 660
975, 653, 675, 662
976, 654, 676, 664
977, 666, 677, 667
978, 677, 657, 667
979, 46, 407, 41
980, 407, 408, 337
981, 408, 409, 338
982, 409, 410, 339
983, 410, 411, 340
984, 411, 412, 341
985, 412, 413, 342
986, 413, 414, 343
987, 414, 415, 344
988, 415, 416, 345
989, 416, 417, 346
990, 417, 418, 347
991, 418, 419, 348
992, 419, 420, 349
993, 420, 421, 350
994, 421, 422, 351
995, 422, 423, 352
996, 423, 424, 353
997, 424, 425, 354
998, 425, 426, 355
999, 426, 42, 356
1000, 42, 33, 356
1001, 407, 337, 41
1002, 408, 338, 337
1003, 409, 339, 338
1004, 410, 340, 339
1005, 411, 341, 340
1006, 412, 342, 341
1007, 413, 343, 342
1008, 414, 344, 343
1009, 415, 345, 344
1010, 416, 346, 345
1011, 417, 347, 346
1012, 418, 348, 347
1013, 419, 349, 348
1014, 420, 350, 349
1015, 421, 351, 350
1016, 422, 352, 351
1017, 423, 353, 352
1018, 424, 354, 353
1019, 425, 355, 354
1020, 426, 356, 355
1021, 42, 47, 427
1022, 358, 357, 428
1023, 429, 430, 360
1024, 430, 431, 362
1025, 364, 363, 432
1026, 432, 433, 365
1027, 433, 43, 366
1028, 360, 359, 429
1029, 358, 428, 359
1030, 359, 428, 429
1031, 432, 365, 364
1032, 433, 366, 365
1033, 427, 428, 357
1034, 430, 362, 361
1035, 43, 34, 366
1036, 357, 42, 427
1037, 430, 361, 360
1038, 363, 362, 431
1039, 431, 432, 363
1040, 374, 44, 434
1041, 40, 374, 375
1042, 44, 48, 434
1043, 375, 374, 434
1044, 434, 45, 375
1045, 46, 41, 406
1046, 376, 45, 435
1047, 377, 376, 436
1048, 378, 377, 437
1049, 379, 378, 438
1050, 380, 379, 439
1051, 381, 380, 440
1052, 382, 381, 441
1053, 383, 382, 442
1054, 384, 383, 443
1055, 385, 384, 444
1056, 386, 385, 445
1057, 387, 386, 446
1058, 388, 387, 447
1059, 389, 388, 448
1060, 390, 389, 449
1061, 391, 390, 450
1062, 392, 391, 451
1063, 393, 392, 452
1064, 394, 393, 453
1065, 395, 394, 453
1066, 396, 395, 454
1067, 397, 396, 455
1068, 398, 397, 456
1069, 399, 398, 457
1070, 400, 399, 458
1071, 401, 400, 459
1072, 402, 401, 460
1073, 403, 402, 461
1074, 404, 403, 462
1075, 405, 404, 463
1076, 406, 405, 464
1077, 376, 435, 436
1078, 45, 49, 435
1079, 436, 437, 377
1080, 437, 438, 378
1081, 438, 439, 379
1082, 439, 440, 380
1083, 440, 441, 381
1084, 441, 442, 382
1085, 442, 443, 383
1086, 443, 444, 384
1087, 444, 445, 385
1088, 445, 446, 386
1089, 446, 447, 387
1090, 447, 448, 388
1091, 448, 449, 389
1092, 449, 450, 390
1093, 450, 451, 391
1094, 451, 452, 392
1095, 452, 453, 393
1096, 404, 462, 463
1097, 405, 463, 464
1098, 396, 454, 455
1099, 395, 453, 454
1100, 397, 455, 456
1101, 398, 456, 457
1102, 399, 457, 458
1103, 400, 458, 459
1104, 401, 459, 460
1105, 402, 460, 461
1106, 403, 461, 462
1107, 406, 464, 465
1108, 465, 46, 406
1109, 407, 46, 466
1110, 408, 407, 467
1111, 409, 408, 467
1112, 410, 409, 468
1113, 411, 410, 469
1114, 412, 411, 469
1115, 413, 412, 470
1116, 414, 413, 471
1117, 415, 414, 472
1118, 416, 415, 472
1119, 417, 416, 473
1120, 418, 417, 474
1121, 419, 418, 474
1122, 420, 419, 475
1123, 421, 420, 476
1124, 422, 421, 476
1125, 423, 422, 477
1126, 424, 423, 478
1127, 425, 424, 478
1128, 426, 425, 479
1129, 42, 426, 47
1130, 46, 50, 466
1131, 466, 467, 407
1132, 467, 468, 409
1133, 468, 469, 410
1134, 469, 470, 412
1135, 470, 471, 413
1136, 471, 472, 414
1137, 472, 473, 416
1138, 473, 474, 417
1139, 474, 475, 419
1140, 475, 476, 420
1141, 476, 477, 422
1142, 477, 478, 423
1143, 478, 479, 425
1144, 479, 47, 426
1145, 49, 45, 434
1146, 434, 48, 480
1147, 434, 480, 49
1148, 48, 51, 480
1149, 481, 52, 482
1150, 482, 483, 435
1151, 437, 436, 484
1152, 485, 438, 484
1153, 485, 486, 439
1154, 486, 487, 441
1155, 443, 442, 488
1156, 489, 444, 488
1157, 489, 490, 445
1158, 490, 491, 447
1159, 492, 493, 449
1160, 493, 494, 451
1161, 453, 452, 495
1162, 496, 454, 495
1163, 496, 497, 455
1164, 457, 456, 498
1165, 499, 458, 498
1166, 499, 500, 459
1167, 500, 501, 461
1168, 463, 462, 502
1169, 503, 464, 502
1170, 503, 50, 465
1171, 50, 46, 465
1172, 448, 447, 491
1173, 449, 448, 492
1174, 481, 482, 49
1175, 492, 448, 491
1176, 482, 435, 49
1177, 435, 483, 436
1178, 483, 484, 436
1179, 439, 486, 440
1180, 486, 441, 440
1181, 487, 488, 442
1182, 445, 490, 446
1183, 490, 447, 446
1184, 487, 442, 441
1185, 493, 451, 450
1186, 494, 495, 452
1187, 453, 495, 454
1188, 455, 497, 456
1189, 497, 498, 456
1190, 459, 500, 460
1191, 500, 461, 460
1192, 463, 502, 464
1193, 439, 438, 485
1194, 445, 444, 489
1195, 450, 449, 493
1196, 494, 452, 451
1197, 454, 496, 455
1198, 464, 503, 465
1199, 459, 458, 499
1200, 462, 461, 501
1201, 437, 484, 438
1202, 443, 488, 444
1203, 457, 498, 458
1204, 501, 502, 462
**
** Node sets +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Element sets ++++++++++++++++++++++++++++++++++++++++++++
**
*Elset, Elset=2mm
5, 15, 18, 21, 199, 200, 201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 221, 222, 223, 224, 225, 226, 
227, 228, 229, 230, 231, 232, 392, 393, 394, 395, 396, 397, 398, 399, 400, 401, 
402, 403, 404, 405, 406, 407, 408, 409, 410, 411, 412, 413, 414, 415, 416, 417, 
418, 419, 420, 421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 431, 432, 433, 
434, 435, 436, 437, 438, 439, 440, 441, 442, 443, 444, 445, 446, 447, 448, 449, 
450, 451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 463, 464, 465, 
466, 467, 468, 469, 470, 471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 481, 
482, 483, 484, 485, 604, 605, 606, 607, 608, 609, 610, 611, 612, 613, 614, 615, 
616, 617, 618, 619, 620, 621, 622, 623, 624, 625, 626, 627, 628, 629, 630, 631, 
632, 633, 634, 635, 636, 637, 638, 639, 640, 641, 642, 643, 644, 645, 646, 647, 
648, 649, 650, 651, 652, 653, 654, 655, 656, 657, 658, 659, 660, 661, 662, 663, 
664, 665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 675, 676, 677, 678, 679, 
680, 681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 691, 692, 693, 694, 695, 
696, 697, 698, 699, 700, 701, 702, 703, 704, 705, 706, 707, 708, 709, 710, 711, 
712, 713, 714, 715, 716, 717, 718, 719, 720, 721, 722, 723, 724, 725, 726, 727, 
728, 729, 730, 731, 732, 733, 734, 735, 736, 737, 738, 739, 740, 741, 742, 743, 
744, 745, 746, 747, 748, 749, 750, 751, 752, 753, 754, 755, 756, 757, 758, 759, 
760, 761, 762, 763, 764, 765, 766, 767, 768, 769, 770, 771, 772, 773, 774, 775, 
776, 777, 778, 779, 780, 781, 782, 783, 784, 785, 786, 787, 788, 789, 790, 791, 
792, 793, 794, 795, 796, 829, 839, 840, 841, 842, 843, 844, 845, 846, 847, 848, 
849, 850, 851, 852, 853, 854, 855, 856, 857, 858, 859, 860, 861, 862, 863, 864, 
865, 866, 867, 868, 869, 870, 871, 872, 873, 874, 875, 876, 877, 878, 879, 880, 
881, 882, 883, 884, 885, 886, 887, 888, 889, 890, 891, 892, 893, 894, 895, 896, 
897, 898, 899, 900, 901, 902, 903, 904, 905, 906, 907, 908, 909, 910, 911, 912, 
913, 914, 915, 916, 917, 918, 919, 920, 921, 922, 923, 924, 925, 926, 927, 928, 
929, 930, 931, 932, 933, 934, 935, 936, 937, 938, 939, 940, 941, 942, 943, 944, 
945, 946, 947, 948, 949, 950, 951, 952, 953, 954, 955, 956, 957, 958, 959, 960, 
961, 962, 963, 964, 965, 966, 967, 968, 969, 970, 971, 972, 973, 974, 975, 976, 
977, 978, 979, 980, 981, 982, 983, 984, 985, 986, 987, 988, 989, 990, 991, 992, 
993, 994, 995, 996, 997, 998, 999, 1000, 1001, 1002, 1003, 1004, 1005, 1006, 1007, 1008, 
1009, 1010, 1011, 1012, 1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 1040, 1041, 1042, 1043, 
1044, 1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 1054, 1055, 1056, 1057, 1058, 1059, 
1060, 1061, 1062, 1063, 1064, 1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 1073, 1074, 1075, 
1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 
1092, 1093, 1094, 1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 1105, 1106, 1107, 
1108, 1109, 1110, 1111, 1112, 1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 1123, 
1124, 1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 
1140, 1141, 1142, 1143, 1144, 1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 1155, 
1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 1171, 
1172, 1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 1185, 1186, 1187, 
1188, 1189, 1190, 1191, 1192, 1193, 1194, 1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203, 
1204
*Elset, Elset=inlet
353, 354, 355, 356, 357, 358, 359, 360, 361, 362, 363, 364, 365, 366, 367, 368, 
369, 370, 371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 381, 382, 383, 384, 
385, 386, 387, 388, 389, 390, 391
**
** Surfaces ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Physical constants ++++++++++++++++++++++++++++++++++++++
**
**
** Coordinate systems ++++++++++++++++++++++++++++++++++++++
**
**
** Materials +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Sections ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Pre-tension sections ++++++++++++++++++++++++++++++++++++
**
**
** Constraints +++++++++++++++++++++++++++++++++++++++++++++
**
**
** Surface interactions ++++++++++++++++++++++++++++++++++++
**
**
** Contact pairs +++++++++++++++++++++++++++++++++++++++++++
**
**
** Amplitudes ++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Initial conditions ++++++++++++++++++++++++++++++++++++++
**
**
** Steps +++++++++++++++++++++++++++++++++++++++++++++++++++
**
