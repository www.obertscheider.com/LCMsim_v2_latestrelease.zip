**
** Heading +++++++++++++++++++++++++++++++++++++++++++++++++
**
*Heading
Hash: Zu5F2c0F, Date: 01/02/2024, Unit system: M_KG_S_C
**
** Nodes +++++++++++++++++++++++++++++++++++++++++++++++++++
**
*Node
1, 3.00000000E-001, -3.00000000E-001, 0.00000000E+000
2, 3.00000000E-001, 3.00000000E-001, 0.00000000E+000
3, -3.00000000E-001, 3.00000000E-001, 0.00000000E+000
4, -3.00000000E-001, -3.00000000E-001, 0.00000000E+000
5, -3.99997884E-002, -1.29666381E-004, 0.00000000E+000
6, 4.00000000E-002, -2.77555756E-017, 0.00000000E+000
7, -9.99706129E-003, 2.36998366E-004, 0.00000000E+000
8, 1.00000000E-002, 0.00000000E+000, 0.00000000E+000
9, 3.00000000E-001, -2.60000000E-001, 0.00000000E+000
10, 3.00000000E-001, -2.20000000E-001, 0.00000000E+000
11, 3.00000000E-001, -1.80000000E-001, 0.00000000E+000
12, 3.00000000E-001, -1.40000000E-001, 0.00000000E+000
13, 3.00000000E-001, -1.00000000E-001, 0.00000000E+000
14, 3.00000000E-001, -6.00000000E-002, 0.00000000E+000
15, 3.00000000E-001, -2.00000000E-002, 0.00000000E+000
16, 3.00000000E-001, 2.00000000E-002, 0.00000000E+000
17, 3.00000000E-001, 6.00000000E-002, 0.00000000E+000
18, 3.00000000E-001, 1.00000000E-001, 0.00000000E+000
19, 3.00000000E-001, 1.40000000E-001, 0.00000000E+000
20, 3.00000000E-001, 1.80000000E-001, 0.00000000E+000
21, 3.00000000E-001, 2.20000000E-001, 0.00000000E+000
22, 3.00000000E-001, 2.60000000E-001, 0.00000000E+000
23, 2.60000000E-001, 3.00000000E-001, 0.00000000E+000
24, 2.20000000E-001, 3.00000000E-001, 0.00000000E+000
25, 1.80000000E-001, 3.00000000E-001, 0.00000000E+000
26, 1.40000000E-001, 3.00000000E-001, 0.00000000E+000
27, 1.00000000E-001, 3.00000000E-001, 0.00000000E+000
28, 6.00000000E-002, 3.00000000E-001, 0.00000000E+000
29, 2.00000000E-002, 3.00000000E-001, 0.00000000E+000
30, -2.00000000E-002, 3.00000000E-001, 0.00000000E+000
31, -6.00000000E-002, 3.00000000E-001, 0.00000000E+000
32, -1.00000000E-001, 3.00000000E-001, 0.00000000E+000
33, -1.40000000E-001, 3.00000000E-001, 0.00000000E+000
34, -1.80000000E-001, 3.00000000E-001, 0.00000000E+000
35, -2.20000000E-001, 3.00000000E-001, 0.00000000E+000
36, -2.60000000E-001, 3.00000000E-001, 0.00000000E+000
37, -3.00000000E-001, 2.60000000E-001, 0.00000000E+000
38, -3.00000000E-001, 2.20000000E-001, 0.00000000E+000
39, -3.00000000E-001, 1.80000000E-001, 0.00000000E+000
40, -3.00000000E-001, 1.40000000E-001, 0.00000000E+000
41, -3.00000000E-001, 1.00000000E-001, 0.00000000E+000
42, -3.00000000E-001, 6.00000000E-002, 0.00000000E+000
43, -3.00000000E-001, 2.00000000E-002, 0.00000000E+000
44, -3.00000000E-001, -2.00000000E-002, 0.00000000E+000
45, -3.00000000E-001, -6.00000000E-002, 0.00000000E+000
46, -3.00000000E-001, -1.00000000E-001, 0.00000000E+000
47, -3.00000000E-001, -1.40000000E-001, 0.00000000E+000
48, -3.00000000E-001, -1.80000000E-001, 0.00000000E+000
49, -3.00000000E-001, -2.20000000E-001, 0.00000000E+000
50, -3.00000000E-001, -2.60000000E-001, 0.00000000E+000
51, -2.60000000E-001, -3.00000000E-001, 0.00000000E+000
52, -2.20000000E-001, -3.00000000E-001, 0.00000000E+000
53, -1.80000000E-001, -3.00000000E-001, 0.00000000E+000
54, -1.40000000E-001, -3.00000000E-001, 0.00000000E+000
55, -1.00000000E-001, -3.00000000E-001, 0.00000000E+000
56, -6.00000000E-002, -3.00000000E-001, 0.00000000E+000
57, -2.00000000E-002, -3.00000000E-001, 0.00000000E+000
58, 2.00000000E-002, -3.00000000E-001, 0.00000000E+000
59, 6.00000000E-002, -3.00000000E-001, 0.00000000E+000
60, 1.00000000E-001, -3.00000000E-001, 0.00000000E+000
61, 1.40000000E-001, -3.00000000E-001, 0.00000000E+000
62, 1.80000000E-001, -3.00000000E-001, 0.00000000E+000
63, 2.20000000E-001, -3.00000000E-001, 0.00000000E+000
64, 2.60000000E-001, -3.00000000E-001, 0.00000000E+000
65, -3.60853426E-002, 1.72590184E-002, 0.00000000E+000
66, -2.49983172E-002, 3.12263540E-002, 0.00000000E+000
67, -8.95707238E-003, 3.89840694E-002, 0.00000000E+000
68, 8.87667390E-003, 3.90024374E-002, 0.00000000E+000
69, 2.49127463E-002, 3.12946403E-002, 0.00000000E+000
70, 3.60305630E-002, 1.73729754E-002, 0.00000000E+000
71, 3.46419071E-002, -1.99986350E-002, 0.00000000E+000
72, 2.00137419E-002, -3.46330710E-002, 0.00000000E+000
73, 3.38015909E-005, -4.00002254E-002, 0.00000000E+000
74, -1.99553898E-002, -3.46664667E-002, 0.00000000E+000
75, -3.45849880E-002, -2.00960133E-002, 0.00000000E+000
76, -9.65475747E-003, 2.60505090E-003, 0.00000000E+000
77, -8.75938217E-003, 4.82380525E-003, 0.00000000E+000
78, -7.36296845E-003, 6.76663462E-003, 0.00000000E+000
79, -5.54478825E-003, 8.32192299E-003, 0.00000000E+000
80, -3.40921923E-003, 9.40079668E-003, 0.00000000E+000
81, -1.07840898E-003, 9.94130206E-003, 0.00000000E+000
82, 1.31407382E-003, 9.91368193E-003, 0.00000000E+000
83, 3.63123313E-003, 9.31765449E-003, 0.00000000E+000
84, 5.74060719E-003, 8.18824718E-003, 0.00000000E+000
85, 7.52130270E-003, 6.59021440E-003, 0.00000000E+000
86, 8.87152894E-003, 4.61495927E-003, 0.00000000E+000
87, 9.71374558E-003, 2.37546408E-003, 0.00000000E+000
88, 9.70506635E-003, -2.41086260E-003, 0.00000000E+000
89, 8.83760360E-003, -4.67950816E-003, 0.00000000E+000
90, 7.44878614E-003, -6.67210205E-003, 0.00000000E+000
91, 5.62054477E-003, -8.27109479E-003, 0.00000000E+000
92, 3.46073325E-003, -9.38215670E-003, 0.00000000E+000
93, 1.09676578E-003, -9.93974268E-003, 0.00000000E+000
94, -1.33189966E-003, -9.91095897E-003, 0.00000000E+000
95, -3.68198834E-003, -9.29750359E-003, 0.00000000E+000
96, -5.81486104E-003, -8.13556625E-003, 0.00000000E+000
97, -7.60469278E-003, -6.49369334E-003, 0.00000000E+000
98, -8.94589568E-003, -4.46874418E-003, 0.00000000E+000
99, -9.75934790E-003, -2.18017698E-003, 0.00000000E+000
100, 4.25200662E-002, 3.39556478E-002, 0.00000000E+000
101, -4.05494334E-002, 3.58349579E-002, 0.00000000E+000
102, -4.23627668E-002, -3.78532533E-002, 0.00000000E+000
103, 4.01450723E-002, -4.03609172E-002, 0.00000000E+000
104, -3.03623692E-003, 5.51402132E-002, 0.00000000E+000
105, 1.20902482E-001, 2.65772298E-001, 0.00000000E+000
106, -1.20000000E-001, 2.65358984E-001, 0.00000000E+000
107, 2.68191859E-001, 1.20057216E-001, 0.00000000E+000
108, -2.65358984E-001, 1.20000000E-001, 0.00000000E+000
109, -2.65351280E-001, -1.21035233E-001, 0.00000000E+000
110, -1.21348780E-001, -2.64273282E-001, 0.00000000E+000
111, 1.20016252E-001, -2.68573017E-001, 0.00000000E+000
112, 2.67169234E-001, -1.22157505E-001, 0.00000000E+000
113, 2.67095262E-001, 3.42054144E-003, 0.00000000E+000
114, -2.68026627E-001, -6.18927452E-004, 0.00000000E+000
115, -2.54538327E-004, -2.69128059E-001, 0.00000000E+000
116, 1.17366714E-004, 2.61225376E-001, 0.00000000E+000
117, -1.99660785E-001, 2.67740665E-001, 0.00000000E+000
118, -2.66962874E-001, -1.97063735E-001, 0.00000000E+000
119, 2.66888659E-001, 1.97330168E-001, 0.00000000E+000
120, 2.00979440E-001, -2.68989503E-001, 0.00000000E+000
121, 5.51591710E-002, -2.52078299E-002, 0.00000000E+000
122, 6.07819985E-002, -4.61401355E-002, 0.00000000E+000
123, 4.53662092E-002, -6.19157749E-002, 0.00000000E+000
124, 6.75434696E-002, -6.76724077E-002, 0.00000000E+000
125, 7.46144418E-002, -2.64588180E-002, 0.00000000E+000
126, 5.06868090E-002, -8.54446439E-002, 0.00000000E+000
127, 7.38102919E-002, -9.26271851E-002, 0.00000000E+000
128, 5.53555666E-002, -1.10598836E-001, 0.00000000E+000
129, 8.08359189E-002, -1.18302877E-001, 0.00000000E+000
130, 1.00635748E-001, -9.79032808E-002, 0.00000000E+000
131, 1.07852711E-001, -1.26142361E-001, 0.00000000E+000
132, 2.97602721E-002, -1.01702566E-001, 0.00000000E+000
133, 6.18477695E-002, -1.35774603E-001, 0.00000000E+000
134, 1.28374679E-001, -1.05133852E-001, 0.00000000E+000
135, 1.36206916E-001, -1.34382225E-001, 0.00000000E+000
136, 1.14609608E-001, -1.55643203E-001, 0.00000000E+000
137, 1.44540250E-001, -1.64561750E-001, 0.00000000E+000
138, 1.57555307E-001, -1.12850333E-001, 0.00000000E+000
139, 1.49014956E-001, -8.33180259E-002, 0.00000000E+000
140, -5.33702544E-002, -1.44730984E-002, 0.00000000E+000
141, -6.28540452E-002, -3.58137546E-002, 0.00000000E+000
142, -5.35979382E-002, -6.08126687E-002, 0.00000000E+000
143, -7.51142182E-002, -1.75877048E-002, 0.00000000E+000
144, -8.75386479E-002, -3.90198913E-002, 0.00000000E+000
145, -9.81378382E-002, -1.85407480E-002, 0.00000000E+000
146, -1.10417579E-001, -4.02536940E-002, 0.00000000E+000
147, -1.23256405E-001, -1.95066682E-002, 0.00000000E+000
148, -1.11419845E-001, 3.19564884E-003, 0.00000000E+000
149, -1.35393563E-001, -4.20811724E-002, 0.00000000E+000
150, -1.20568744E-001, -6.37492055E-002, 0.00000000E+000
151, -1.37373373E-001, 1.97895159E-003, 0.00000000E+000
152, -1.24337198E-001, 2.58656321E-002, 0.00000000E+000
153, -1.52103527E-001, 2.46410280E-002, 0.00000000E+000
154, -1.38362705E-001, 4.98650747E-002, 0.00000000E+000
155, -1.47807962E-001, -6.62822636E-002, 0.00000000E+000
156, -1.32271569E-001, -8.95377046E-002, 0.00000000E+000
157, -1.60605470E-001, 2.66430170E-003, 0.00000000E+000
158, -1.67932527E-001, 4.86463688E-002, 0.00000000E+000
159, -1.54022715E-001, 7.47085744E-002, 0.00000000E+000
160, -1.23895231E-001, 7.58271148E-002, 0.00000000E+000
161, -1.39601506E-001, 1.00733177E-001, 0.00000000E+000
162, -1.09480553E-001, 1.01848758E-001, 0.00000000E+000
163, -1.25139496E-001, 1.27284401E-001, 0.00000000E+000
164, -9.49390020E-002, 1.27684436E-001, 0.00000000E+000
165, -1.55829638E-001, 1.27564255E-001, 0.00000000E+000
166, -1.60355519E-001, -9.28203179E-002, 0.00000000E+000
167, -1.42856153E-001, -1.17408485E-001, 0.00000000E+000
168, -1.10053826E-001, -1.10177708E-001, 0.00000000E+000
169, -1.77492858E-001, -6.76283652E-002, 0.00000000E+000
170, -1.24232290E-001, -1.41835659E-001, 0.00000000E+000
171, -9.20733302E-002, -1.38483053E-001, 0.00000000E+000
172, -1.53664337E-001, -1.44169759E-001, 0.00000000E+000
173, -1.41456977E-001, 1.54850713E-001, 0.00000000E+000
174, -1.73702762E-001, 1.55188513E-001, 0.00000000E+000
175, -7.91966596E-002, 1.04174380E-001, 0.00000000E+000
176, -6.45538126E-002, 1.28309606E-001, 0.00000000E+000
177, -7.98308271E-002, 1.53617171E-001, 0.00000000E+000
178, -5.00702391E-002, 1.53097759E-001, 0.00000000E+000
179, -3.53176438E-002, 1.28155415E-001, 0.00000000E+000
180, -2.11115512E-002, 1.52442673E-001, 0.00000000E+000
181, -7.50322945E-003, 1.27935022E-001, 0.00000000E+000
182, 7.07243588E-003, 1.51791681E-001, 0.00000000E+000
183, 1.99347903E-002, 1.27494585E-001, 0.00000000E+000
184, 3.50201506E-002, 1.51337760E-001, 0.00000000E+000
185, 4.81214645E-002, 1.26837744E-001, 0.00000000E+000
186, 6.31919720E-002, 1.50999915E-001, 0.00000000E+000
187, 7.69458033E-002, 1.26168410E-001, 0.00000000E+000
188, 9.21952842E-002, 1.50947894E-001, 0.00000000E+000
189, 1.06813417E-001, 1.24334280E-001, 0.00000000E+000
190, 1.22348612E-001, 1.50769264E-001, 0.00000000E+000
191, 1.36898632E-001, 1.23857944E-001, 0.00000000E+000
192, 1.21377193E-001, 9.73957325E-002, 0.00000000E+000
193, 1.51226192E-001, 9.69469082E-002, 0.00000000E+000
194, 1.35438411E-001, 7.10859760E-002, 0.00000000E+000
195, 1.65336426E-001, 7.01974911E-002, 0.00000000E+000
196, 1.49111326E-001, 4.47188954E-002, 0.00000000E+000
197, 1.53628709E-001, 1.49565969E-001, 0.00000000E+000
198, 4.77105823E-002, 1.76534724E-001, 0.00000000E+000
199, -6.45973270E-002, 1.79858852E-001, 0.00000000E+000
200, 1.20188506E-001, 4.58446388E-002, 0.00000000E+000
201, 1.33307536E-001, 2.05973659E-002, 0.00000000E+000
202, 1.63496148E-001, 1.92760461E-002, 0.00000000E+000
203, 6.15525290E-002, 1.03609136E-001, 0.00000000E+000
204, 1.79122335E-001, -9.07053765E-002, 0.00000000E+000
205, -1.06604498E-001, -1.68090548E-001, 0.00000000E+000
206, -7.41666195E-002, -1.64360191E-001, 0.00000000E+000
207, -6.09253925E-002, -1.35601131E-001, 0.00000000E+000
208, -4.28440051E-002, -1.60254298E-001, 0.00000000E+000
209, -5.49509208E-002, -1.90292008E-001, 0.00000000E+000
210, -2.25409385E-002, -1.85867725E-001, 0.00000000E+000
211, -1.84588776E-001, 7.37274115E-002, 0.00000000E+000
212, -6.36793441E-003, 1.77081814E-001, 0.00000000E+000
213, -2.68072822E-001, 1.99625565E-001, 0.00000000E+000
214, 1.99113280E-001, 2.65416749E-001, 0.00000000E+000
215, -1.99668518E-001, -2.65567529E-001, 0.00000000E+000
216, 2.65358984E-001, -2.00000000E-001, 0.00000000E+000
217, -1.16431576E-002, -5.43782281E-002, 0.00000000E+000
218, 1.70129938E-001, -6.08087631E-002, 0.00000000E+000
219, 2.01337737E-001, -6.80571600E-002, 0.00000000E+000
220, -1.58066987E-001, 1.82609585E-001, 0.00000000E+000
221, 1.06702395E-001, 1.77416520E-001, 0.00000000E+000
222, 1.87960726E-001, -1.21043961E-001, 0.00000000E+000
223, 1.82373032E-001, 9.63995483E-002, 0.00000000E+000
224, 1.97273310E-001, 6.80923021E-002, 0.00000000E+000
225, -9.87896757E-002, 2.58562917E-002, 0.00000000E+000
226, 1.40312986E-001, -5.44258772E-002, 0.00000000E+000
227, 1.06096150E-001, 2.50763968E-002, 0.00000000E+000
228, 9.47598615E-002, 4.82481942E-002, 0.00000000E+000
229, -2.10175274E-002, 1.06474991E-001, 0.00000000E+000
230, -5.42476277E-002, 1.96706578E-002, 0.00000000E+000
231, -2.36960734E-002, 4.89973372E-002, 0.00000000E+000
232, -4.36720672E-002, 5.45435398E-002, 0.00000000E+000
233, 5.31749894E-002, 1.47842243E-002, 0.00000000E+000
234, 3.03435422E-002, 4.74956682E-002, 0.00000000E+000
235, -1.98279315E-001, 4.65911797E-002, 0.00000000E+000
236, -3.14070518E-002, -1.31784286E-001, 0.00000000E+000
237, -1.91096837E-001, -9.55674805E-002, 0.00000000E+000
238, -2.08984763E-001, -6.93075637E-002, 0.00000000E+000
239, 1.21392059E-001, -1.86729032E-001, 0.00000000E+000
240, 1.53199938E-001, -1.96410257E-001, 0.00000000E+000
241, 5.02975436E-002, 5.15339285E-002, 0.00000000E+000
242, 1.92267075E-001, -3.72347467E-002, 0.00000000E+000
243, 1.13252786E-001, -7.73429937E-004, 0.00000000E+000
244, 3.76015828E-002, 6.66538922E-002, 0.00000000E+000
245, -1.93776459E-001, 1.83304881E-001, 0.00000000E+000
246, -2.16743561E-001, 7.28185829E-002, 0.00000000E+000
247, 9.25486131E-002, -1.76560189E-001, 0.00000000E+000
248, -4.84201466E-002, -1.08448686E-001, 0.00000000E+000
249, -2.11200241E-002, -1.05044045E-001, 0.00000000E+000
250, -9.55541583E-002, 1.80941087E-001, 0.00000000E+000
251, -7.97291713E-002, 2.08433330E-001, 0.00000000E+000
252, -4.70408218E-002, 2.07392760E-001, 0.00000000E+000
253, -2.00502177E-001, 1.00066642E-001, 0.00000000E+000
254, 7.09633448E-003, -6.24570915E-002, 0.00000000E+000
255, 1.76903209E-001, -1.72313958E-001, 0.00000000E+000
256, 9.75639613E-002, -2.09004437E-001, 0.00000000E+000
257, 6.35999393E-002, -1.95826666E-001, 0.00000000E+000
258, 7.24654198E-002, -2.32039612E-001, 0.00000000E+000
259, 2.23957753E-001, -4.47224244E-002, 0.00000000E+000
260, -2.05916088E-001, 1.50658662E-001, 0.00000000E+000
261, -3.48860386E-002, -2.16165335E-001, 0.00000000E+000
262, -6.86010216E-002, -2.22012348E-001, 0.00000000E+000
263, 3.89498615E-003, -2.11445714E-001, 0.00000000E+000
264, 9.91681375E-003, -1.78297107E-001, 0.00000000E+000
265, 2.11760402E-001, -1.40756933E-002, 0.00000000E+000
266, -6.05971726E-002, 4.33128401E-002, 0.00000000E+000
267, 1.85819053E-001, -2.05251726E-001, 0.00000000E+000
268, -1.12747072E-001, 2.08694097E-001, 0.00000000E+000
269, -6.31932878E-002, 2.37187976E-001, 0.00000000E+000
270, -1.56922857E-002, 6.93800461E-002, 0.00000000E+000
271, 3.35443430E-003, 7.48627508E-002, 0.00000000E+000
272, -4.60246413E-003, -1.27699257E-001, 0.00000000E+000
273, -1.95712544E-001, -4.12039457E-002, 0.00000000E+000
274, -6.45433423E-002, 6.51181389E-002, 0.00000000E+000
275, -2.26812157E-001, -4.20588983E-002, 0.00000000E+000
276, -2.14744947E-001, -1.32072192E-002, 0.00000000E+000
277, 6.21405797E-002, 3.20937188E-002, 0.00000000E+000
278, 2.10596176E-001, -1.78949337E-001, 0.00000000E+000
279, 2.14350678E-001, 9.92580931E-002, 0.00000000E+000
280, 2.29873969E-001, 7.02100806E-002, 0.00000000E+000
281, 1.97085913E-001, 1.27159924E-001, 0.00000000E+000
282, -2.30132065E-001, 4.39322775E-002, 0.00000000E+000
283, -2.38223787E-001, -6.81883594E-002, 0.00000000E+000
284, 1.59552139E-001, -2.28734143E-001, 0.00000000E+000
285, -1.70398571E-001, 2.10704621E-001, 0.00000000E+000
286, -2.08092255E-001, 2.13869531E-001, 0.00000000E+000
287, -4.53080809E-002, 7.67233474E-002, 0.00000000E+000
288, 7.36619389E-002, 1.27505902E-002, 0.00000000E+000
289, 2.32925005E-001, -7.59529101E-002, 0.00000000E+000
290, 2.13502175E-001, 4.03985052E-002, 0.00000000E+000
291, -8.34459295E-002, 4.82295403E-002, 0.00000000E+000
292, -2.53463183E-001, 6.82684865E-002, 0.00000000E+000
293, -4.80916610E-002, -2.47437999E-001, 0.00000000E+000
294, 6.01678102E-002, 6.80258733E-002, 0.00000000E+000
295, 2.25748622E-001, -2.12049319E-001, 0.00000000E+000
296, -3.86171338E-002, -8.26635198E-002, 0.00000000E+000
297, -6.45667383E-002, -8.59800149E-002, 0.00000000E+000
298, 4.01216154E-002, -2.22800013E-001, 0.00000000E+000
299, 1.07768165E-001, 7.10687118E-002, 0.00000000E+000
300, 4.93947872E-002, -2.55950522E-001, 0.00000000E+000
301, -4.83467950E-002, 1.02554416E-001, 0.00000000E+000
302, -7.64570275E-002, -6.13549592E-002, 0.00000000E+000
303, -9.00495678E-002, -8.70951307E-002, 0.00000000E+000
304, 9.06568777E-002, 9.64448745E-002, 0.00000000E+000
305, -2.62570165E-001, -4.22819605E-002, 0.00000000E+000
306, -1.18343996E-002, -7.88471561E-002, 0.00000000E+000
307, 5.37733324E-003, 1.01119395E-001, 0.00000000E+000
308, 3.38852185E-002, 1.04567930E-001, 0.00000000E+000
309, -2.84185792E-002, 2.35879955E-001, 0.00000000E+000
310, 2.56470611E-001, -5.25115370E-002, 0.00000000E+000
311, 2.48321659E-001, 4.04114016E-002, 0.00000000E+000
312, -9.02709958E-002, 7.60710648E-002, 0.00000000E+000
313, 1.20625273E-001, -7.62472848E-002, 0.00000000E+000
314, 1.11236680E-001, -5.05121899E-002, 0.00000000E+000
315, 2.66668659E-001, 7.58410296E-002, 0.00000000E+000
316, -8.75135011E-002, 3.41754977E-003, 0.00000000E+000
317, -2.65966709E-001, 1.58947390E-001, 0.00000000E+000
318, -7.52078638E-002, 2.35481068E-002, 0.00000000E+000
319, -1.09850289E-001, 5.02857864E-002, 0.00000000E+000
320, 1.59590582E-001, 2.65988920E-001, 0.00000000E+000
321, 1.78995900E-001, 2.32226853E-001, 0.00000000E+000
322, 2.19678239E-001, 2.34299340E-001, 0.00000000E+000
323, 2.01482868E-001, 1.97990193E-001, 0.00000000E+000
324, 1.59921080E-001, 2.02286204E-001, 0.00000000E+000
325, 1.40857973E-001, 2.34055514E-001, 0.00000000E+000
326, 1.02990742E-001, 2.32817120E-001, 0.00000000E+000
327, 8.24204852E-002, 2.65620802E-001, 0.00000000E+000
328, 6.56164702E-002, 2.33689956E-001, 0.00000000E+000
329, 4.29568775E-002, 2.65053872E-001, 0.00000000E+000
330, 2.99556002E-002, 2.33591974E-001, 0.00000000E+000
331, 2.39124974E-001, 2.65830998E-001, 0.00000000E+000
332, 2.66360744E-001, 1.59172625E-001, 0.00000000E+000
333, 2.34982212E-001, 1.76849879E-001, 0.00000000E+000
334, -1.59802729E-001, 2.68594212E-001, 0.00000000E+000
335, 2.32789679E-001, 1.34440100E-001, 0.00000000E+000
336, -1.24111008E-002, -1.55591929E-001, 0.00000000E+000
337, 2.67843702E-001, -1.60397982E-001, 0.00000000E+000
338, 2.34214591E-001, -1.46054777E-001, 0.00000000E+000
339, -1.60189017E-001, -2.65468113E-001, 0.00000000E+000
340, -1.79941837E-001, -2.32028603E-001, 0.00000000E+000
341, -2.20130797E-001, -2.34399832E-001, 0.00000000E+000
342, -1.99462009E-001, -1.97343186E-001, 0.00000000E+000
343, -1.57689894E-001, -2.00559124E-001, 0.00000000E+000
344, -1.41452651E-001, -2.31665673E-001, 0.00000000E+000
345, -1.24098395E-001, -1.99051581E-001, 0.00000000E+000
346, -2.66333795E-001, -1.59300563E-001, 0.00000000E+000
347, -2.32624140E-001, -1.39988486E-001, 0.00000000E+000
348, -2.33751106E-001, -1.76721462E-001, 0.00000000E+000
349, -2.02552946E-001, -1.59053821E-001, 0.00000000E+000
350, -1.04277502E-001, -2.28383939E-001, 0.00000000E+000
351, -2.39257619E-001, -2.66480688E-001, 0.00000000E+000
352, 1.74165644E-002, -1.48960091E-001, 0.00000000E+000
353, 3.91992916E-002, -1.71916104E-001, 0.00000000E+000
354, 1.60130343E-001, -3.19053973E-002, 0.00000000E+000
355, 1.77476656E-001, -8.27559258E-003, 0.00000000E+000
356, 1.28537058E-001, -2.78148675E-002, 0.00000000E+000
357, -8.37106297E-002, -2.55840244E-001, 0.00000000E+000
358, -1.39968143E-001, 2.34006505E-001, 0.00000000E+000
359, 2.59934971E-001, -2.39068862E-001, 0.00000000E+000
360, 9.25419862E-002, -7.27250935E-002, 0.00000000E+000
361, -2.62643046E-001, 2.39996709E-001, 0.00000000E+000
362, 1.22577942E-002, -8.43787749E-002, 0.00000000E+000
363, 6.13892840E-002, -6.03528466E-003, 0.00000000E+000
364, 8.57768845E-002, -5.70385886E-003, 0.00000000E+000
365, 9.91363842E-002, -2.71085628E-002, 0.00000000E+000
366, -2.65070520E-001, 3.42809412E-002, 0.00000000E+000
367, 1.45897532E-001, -4.69336605E-003, 0.00000000E+000
368, 8.74887276E-002, 2.05195743E-001, 0.00000000E+000
369, -8.87831594E-002, -1.95365103E-001, 0.00000000E+000
370, -8.06418430E-002, 2.67753655E-001, 0.00000000E+000
371, 1.80061257E-001, 4.35593848E-002, 0.00000000E+000
372, -2.35041516E-001, 1.79020390E-001, 0.00000000E+000
373, -1.65070334E-001, -4.22577890E-002, 0.00000000E+000
374, -2.30086412E-001, -1.01036029E-001, 0.00000000E+000
375, 8.41808624E-002, -2.66025128E-001, 0.00000000E+000
376, -4.20227239E-002, 2.67007827E-001, 0.00000000E+000
377, 1.60051474E-001, -2.64789353E-001, 0.00000000E+000
378, -2.38772194E-001, 2.70280543E-001, 0.00000000E+000
379, 2.38534308E-001, -2.70510258E-001, 0.00000000E+000
380, -2.61848122E-001, -2.36503137E-001, 0.00000000E+000
381, 1.28756193E-001, -2.17506270E-001, 0.00000000E+000
382, 3.74785572E-002, -1.27565459E-001, 0.00000000E+000
383, -7.62280145E-002, -1.11684717E-001, 0.00000000E+000
384, -1.10489993E-001, 1.54297135E-001, 0.00000000E+000
385, 8.27505370E-002, 6.74983992E-002, 0.00000000E+000
386, 1.66923924E-001, 1.23392633E-001, 0.00000000E+000
387, 2.61788784E-001, 2.36530069E-001, 0.00000000E+000
388, -1.55836580E-002, 2.06618048E-001, 0.00000000E+000
389, -2.35585327E-001, 1.01245825E-001, 0.00000000E+000
390, 1.65147811E-001, -1.42286196E-001, 0.00000000E+000
391, 8.76033160E-002, -1.44965227E-001, 0.00000000E+000
392, 1.37734674E-001, 1.77100501E-001, 0.00000000E+000
393, -1.48349204E-001, -2.08347716E-002, 0.00000000E+000
394, -1.69935373E-001, 1.00566124E-001, 0.00000000E+000
395, 2.09948592E-002, 1.72003164E-001, 0.00000000E+000
396, -3.41285886E-002, 1.79415317E-001, 0.00000000E+000
397, -1.72191540E-001, -1.19740311E-001, 0.00000000E+000
398, 1.22888870E-001, 2.05641439E-001, 0.00000000E+000
399, -2.02871659E-001, -1.25725255E-001, 0.00000000E+000
400, 2.08791934E-001, -9.76750023E-002, 0.00000000E+000
401, 2.04878375E-001, 1.58374451E-001, 0.00000000E+000
402, 2.67042726E-001, -8.55465069E-002, 0.00000000E+000
403, 7.76752140E-002, 1.75083181E-001, 0.00000000E+000
404, -1.79313662E-001, 2.22411742E-002, 0.00000000E+000
405, 1.66360856E-002, 6.06811755E-002, 0.00000000E+000
406, 2.37505551E-002, 8.25499614E-002, 0.00000000E+000
407, 7.13433136E-002, 4.97194191E-002, 0.00000000E+000
408, 2.50974431E-002, -5.39086384E-002, 0.00000000E+000
409, -9.93799196E-002, 2.36905758E-001, 0.00000000E+000
410, -1.37163833E-001, -1.70626575E-001, 0.00000000E+000
411, -2.08975290E-001, 1.79305055E-002, 0.00000000E+000
412, -6.65412134E-002, 2.09430046E-003, 0.00000000E+000
413, 1.98708966E-001, -1.48246841E-001, 0.00000000E+000
414, 5.33007708E-002, 2.05122429E-001, 0.00000000E+000
415, -3.32326327E-002, -5.94864454E-002, 0.00000000E+000
416, -2.36547032E-001, 1.39207404E-001, 0.00000000E+000
417, -1.26346900E-001, 1.81059280E-001, 0.00000000E+000
418, 4.70458571E-002, 8.62457491E-002, 0.00000000E+000
419, -6.36614935E-002, 8.65046427E-002, 0.00000000E+000
420, -1.86216601E-001, 1.26569392E-001, 0.00000000E+000
421, 8.43091601E-002, -4.84362013E-002, 0.00000000E+000
422, -1.14700786E-002, 8.78751426E-002, 0.00000000E+000
423, 1.76677870E-001, 1.73559992E-001, 0.00000000E+000
424, 6.63854350E-002, -1.62643846E-001, 0.00000000E+000
425, 2.43755066E-001, -2.14045216E-002, 0.00000000E+000
426, 2.96020169E-003, -1.04244077E-001, 0.00000000E+000
427, 1.06767172E-001, -2.39620100E-001, 0.00000000E+000
428, -2.37914203E-001, 1.10949349E-002, 0.00000000E+000
429, 4.45150798E-004, 2.31786554E-001, 0.00000000E+000
430, -2.68034462E-001, -8.50999425E-002, 0.00000000E+000
431, -1.54698133E-002, -2.42601924E-001, 0.00000000E+000
432, 2.38044804E-001, -1.06997912E-001, 0.00000000E+000
433, 1.86364816E-002, 2.00391244E-001, 0.00000000E+000
434, 1.97180245E-001, 1.46850378E-002, 0.00000000E+000
435, -2.40535767E-001, -1.57479681E-002, 0.00000000E+000
436, 2.30269135E-001, 1.05725452E-002, 0.00000000E+000
437, 8.27907687E-002, 2.98371421E-002, 0.00000000E+000
438, 1.72774750E-002, -2.45896821E-001, 0.00000000E+000
439, 3.23633630E-002, -1.96310630E-001, 0.00000000E+000
440, 1.91231208E-001, -2.35926209E-001, 0.00000000E+000
441, -1.81824493E-001, -1.06668206E-002, 0.00000000E+000
442, 7.08496539E-002, 8.48399914E-002, 0.00000000E+000
443, 1.79838958E-001, 1.46410594E-001, 0.00000000E+000
444, 2.43677974E-001, 1.00208509E-001, 0.00000000E+000
445, 2.41132384E-001, -1.79645282E-001, 0.00000000E+000
446, 3.00941528E-002, -7.59583745E-002, 0.00000000E+000
447, 2.76615151E-001, 4.00000000E-002, 0.00000000E+000
448, 2.69994507E-001, 2.69994507E-001, 0.00000000E+000
449, -1.71916469E-001, -1.69216372E-001, 0.00000000E+000
450, -2.70172162E-001, -2.70172162E-001, 0.00000000E+000
451, -2.40777860E-001, 2.18219826E-001, 0.00000000E+000
452, 2.71165435E-001, -2.72299092E-001, 0.00000000E+000
453, -2.70624246E-001, 2.70624246E-001, 0.00000000E+000
454, -1.41505535E-001, 2.03414817E-001, 0.00000000E+000
455, -9.92914341E-002, -6.24284795E-002, 0.00000000E+000
456, -3.24861784E-002, -2.71962005E-001, 0.00000000E+000
457, -2.36413404E-001, -2.07405543E-001, 0.00000000E+000
458, -1.81100957E-001, 2.42034157E-001, 0.00000000E+000
459, -2.72107897E-001, 9.16894606E-002, 0.00000000E+000
460, 2.36835108E-001, 2.08255466E-001, 0.00000000E+000
461, -2.90432482E-002, 8.59152778E-002, 0.00000000E+000
462, 2.71143113E-001, -2.74428593E-002, 0.00000000E+000
463, 1.68200914E-002, -1.21270323E-001, 0.00000000E+000
464, -3.12099964E-002, 6.59753051E-002, 0.00000000E+000
465, -2.20794932E-001, 2.42659359E-001, 0.00000000E+000
466, -1.10717039E-001, -8.30979964E-002, 0.00000000E+000
467, -1.80965796E-001, -1.43545768E-001, 0.00000000E+000
468, 1.37620345E-001, -2.44572135E-001, 0.00000000E+000
469, 2.21517904E-001, -2.44857903E-001, 0.00000000E+000
470, 4.77975905E-002, -1.28104374E-002, 0.00000000E+000
471, 2.13544204E-001, -1.24003699E-001, 0.00000000E+000
472, -2.12199219E-001, 1.24442273E-001, 0.00000000E+000
473, 9.23157057E-002, 1.22373681E-002, 0.00000000E+000
474, -5.23415117E-002, 5.29186922E-003, 0.00000000E+000
475, 4.31274163E-002, -1.48996253E-001, 0.00000000E+000
476, 2.68383220E-002, -2.73647425E-001, 0.00000000E+000
477, -6.34540137E-002, -2.74444005E-001, 0.00000000E+000
478, 2.51954456E-004, 1.28750692E-002, 0.00000000E+000
479, -5.77901260E-003, 1.13596745E-002, 0.00000000E+000
480, 5.86950388E-003, 1.10223552E-002, 0.00000000E+000
481, -1.00992974E-002, 7.79035712E-003, 0.00000000E+000
482, 1.05156945E-002, 7.19191369E-003, 0.00000000E+000
483, -1.27660097E-002, 1.36511760E-003, 0.00000000E+000
484, 1.22900434E-002, 1.80892155E-003, 0.00000000E+000
485, -8.88682846E-003, -9.27250089E-003, 0.00000000E+000
486, -1.10737728E-002, -3.95759191E-003, 0.00000000E+000
487, 1.86997558E-004, -1.27828085E-002, 0.00000000E+000
488, 2.79059106E-002, 6.71414549E-003, 0.00000000E+000
489, -2.80431378E-002, 6.48280584E-003, 0.00000000E+000
490, 1.35485542E-002, 2.46697293E-002, 0.00000000E+000
491, -1.26645715E-002, 2.39275563E-002, 0.00000000E+000
492, 1.79584934E-002, -1.89864555E-002, 0.00000000E+000
493, 1.15886094E-002, -4.94445290E-003, 0.00000000E+000
494, 5.51388867E-003, -1.23870208E-002, 0.00000000E+000
495, -5.91067077E-003, -2.74207053E-002, 0.00000000E+000
496, 2.26804861E-002, 1.75577453E-002, 0.00000000E+000
497, 1.39110891E-002, 1.50099565E-002, 0.00000000E+000
498, 1.82040018E-002, 7.80534671E-003, 0.00000000E+000
499, 2.14295366E-002, -6.16480704E-005, 0.00000000E+000
500, 7.09887006E-003, 1.85790129E-002, 0.00000000E+000
501, 3.71333887E-003, 2.45947986E-002, 0.00000000E+000
502, -4.05699086E-003, 2.08331181E-002, 0.00000000E+000
503, -2.28023451E-002, 1.76952419E-002, 0.00000000E+000
504, -1.42411640E-002, 1.43684538E-002, 0.00000000E+000
505, -1.83866033E-002, 7.87550832E-003, 0.00000000E+000
506, -2.04751609E-002, -9.83330509E-004, 0.00000000E+000
507, 1.24019439E-002, -1.57612237E-003, 0.00000000E+000
508, 1.59815940E-002, -3.87450213E-003, 0.00000000E+000
509, 1.32286840E-002, -9.46220093E-003, 0.00000000E+000
510, 2.21404651E-002, -9.18647551E-003, 0.00000000E+000
511, 9.58341109E-003, -1.54698147E-002, 0.00000000E+000
512, 3.87683296E-003, -1.69384517E-002, 0.00000000E+000
513, 6.79367701E-003, -2.48151212E-002, 0.00000000E+000
514, -3.51442811E-003, -1.90592363E-002, 0.00000000E+000
515, -1.36029824E-002, -1.78491559E-002, 0.00000000E+000
516, -4.63848413E-003, -1.41962263E-002, 0.00000000E+000
517, -2.47010667E-002, -1.26281704E-002, 0.00000000E+000
518, 1.13525969E-003, 1.76880823E-002, 0.00000000E+000
519, 3.70306094E-003, 1.41586397E-002, 0.00000000E+000
520, -8.35847743E-003, 1.61802323E-002, 0.00000000E+000
521, 2.95039156E-002, -3.19644623E-003, 0.00000000E+000
522, 8.61906418E-003, -9.90910022E-003, 0.00000000E+000
523, 9.94454945E-003, -7.13347285E-003, 0.00000000E+000
524, -2.95608284E-002, -5.47087495E-003, 0.00000000E+000
525, -1.79038842E-002, -8.50565475E-003, 0.00000000E+000
526, -1.55798441E-002, -1.53064952E-003, 0.00000000E+000
527, -1.24666284E-002, -1.02484701E-002, 0.00000000E+000
528, -1.20485674E-002, -1.50345823E-003, 0.00000000E+000
529, -1.60336028E-002, 2.31752923E-003, 0.00000000E+000
530, -1.27765179E-002, 5.18393251E-003, 0.00000000E+000
531, -1.32480898E-002, 9.37838696E-003, 0.00000000E+000
532, -9.76110187E-003, 1.14101386E-002, 0.00000000E+000
533, -1.05372252E-002, -6.97938396E-003, 0.00000000E+000
534, -9.19263791E-003, -1.38500153E-002, 0.00000000E+000
535, -5.88901680E-003, -1.11169874E-002, 0.00000000E+000
536, 1.56184098E-002, 7.32627202E-004, 0.00000000E+000
537, 1.35897655E-002, 5.29326739E-003, 0.00000000E+000
538, 1.31860920E-002, 9.22413457E-003, 0.00000000E+000
539, 9.83892484E-003, 1.09240390E-002, 0.00000000E+000
540, 1.11706795E-002, 4.23300389E-003, 0.00000000E+000
541, -7.79701368E-003, 9.19850534E-003, 0.00000000E+000
542, -3.07087827E-003, -1.14608969E-002, 0.00000000E+000
543, -3.64802378E-003, 1.51824524E-002, 0.00000000E+000
544, -2.71942240E-003, 1.17122670E-002, 0.00000000E+000
545, 7.94565419E-003, 8.84215843E-003, 0.00000000E+000
546, 7.70301648E-003, 1.40455147E-002, 0.00000000E+000
547, 2.97710017E-003, 1.15618067E-002, 0.00000000E+000
548, -4.78543323E-003, 2.76706993E-002, 0.00000000E+000
549, -1.32683204E-002, -5.45420141E-003, 0.00000000E+000
550, 8.06472395E-003, 9.65837706E-004, 0.00000000E+000
551, -7.77514053E-003, 1.12458442E-003, 0.00000000E+000
552, 1.62593298E-005, -7.90837620E-003, 0.00000000E+000
553, 7.84607546E-005, 7.89615922E-003, 0.00000000E+000
554, -6.64226892E-003, -4.58042519E-003, 0.00000000E+000
555, -5.10697214E-003, 5.96970380E-003, 0.00000000E+000
556, 5.27992342E-003, 5.83625406E-003, 0.00000000E+000
557, 6.62593204E-003, -4.45160397E-003, 0.00000000E+000
558, 3.50205274E-003, -7.16847181E-003, 0.00000000E+000
559, -3.81544872E-003, -6.86565814E-003, 0.00000000E+000
560, -8.23330005E-003, -7.83880258E-004, 0.00000000E+000
561, -6.05940089E-003, -2.66007256E-004, 0.00000000E+000
562, -5.52292596E-003, 1.88093822E-003, 0.00000000E+000
563, -3.74717028E-003, 3.80480536E-004, 0.00000000E+000
564, -3.24404130E-003, 2.65158796E-003, 0.00000000E+000
565, -1.45881792E-003, 1.13044333E-003, 0.00000000E+000
566, -1.94002240E-003, -1.21864653E-003, 0.00000000E+000
567, 3.45085675E-004, -4.49223364E-004, 0.00000000E+000
568, 8.18109529E-004, 1.91093050E-003, 0.00000000E+000
569, 2.62610411E-003, 3.24177054E-004, 0.00000000E+000
570, 2.15473567E-003, -2.03866632E-003, 0.00000000E+000
571, 4.34028277E-003, -1.18176043E-003, 0.00000000E+000
572, 3.06206426E-003, 2.64514192E-003, 0.00000000E+000
573, 1.14941686E-003, 4.14289874E-003, 0.00000000E+000
574, 4.23175135E-003, -3.71549131E-003, 0.00000000E+000
575, 1.66959740E-003, -4.20983888E-003, 0.00000000E+000
576, -4.24184665E-003, -1.83686822E-003, 0.00000000E+000
577, -2.38010423E-003, -3.52586703E-003, 0.00000000E+000
578, -9.98158407E-004, 3.48589710E-003, 0.00000000E+000
579, -3.04088817E-003, 5.21324312E-003, 0.00000000E+000
580, 4.67916363E-003, 1.12926885E-003, 0.00000000E+000
581, -1.26494586E-004, -2.76975195E-003, 0.00000000E+000
582, -6.08888761E-004, -5.45942177E-003, 0.00000000E+000
583, 5.36932747E-003, 3.45133204E-003, 0.00000000E+000
584, -6.38534516E-004, 5.72573255E-003, 0.00000000E+000
585, -2.02419195E-003, 7.59321733E-003, 0.00000000E+000
586, -7.22865943E-003, 3.22787926E-003, 0.00000000E+000
587, 3.28133686E-003, 4.87681907E-003, 0.00000000E+000
588, 3.51710331E-003, 7.10956779E-003, 0.00000000E+000
589, -4.53777765E-003, -4.29014120E-003, 0.00000000E+000
590, -5.08663422E-003, 3.97191830E-003, 0.00000000E+000
591, -6.87450258E-003, -2.45712414E-003, 0.00000000E+000
592, 6.28755330E-003, -2.50806664E-004, 0.00000000E+000
593, 6.26643600E-003, -2.27953684E-003, 0.00000000E+000
594, 8.08497463E-003, -1.13382840E-003, 0.00000000E+000
595, -5.68300982E-003, -6.07309682E-003, 0.00000000E+000
596, 5.11059353E-003, -5.91810623E-003, 0.00000000E+000
597, -1.98265789E-003, -7.48529189E-003, 0.00000000E+000
598, 1.84157026E-003, -8.13750681E-003, 0.00000000E+000
599, 7.55272201E-003, 3.00950772E-003, 0.00000000E+000
600, 1.41442500E-003, 6.29090388E-003, 0.00000000E+000
601, 6.89463337E-003, 4.71272669E-003, 0.00000000E+000
602, 1.37547931E-003, -6.32116497E-003, 0.00000000E+000
603, -6.71028411E-003, 4.96941832E-003, 0.00000000E+000
604, 7.91530315E-003, -3.02667905E-003, 0.00000000E+000
605, -2.47398116E-003, -5.46983268E-003, 0.00000000E+000
606, 1.99105920E-003, 8.10559346E-003, 0.00000000E+000
607, -3.97225046E-003, 7.35207999E-003, 0.00000000E+000
608, 3.19406610E-003, -5.39897429E-003, 0.00000000E+000
609, 6.39403368E-003, 1.73979897E-003, 0.00000000E+000
**
** Elements ++++++++++++++++++++++++++++++++++++++++++++++++
**
*Element, Type=S3, Elset=Shell_part-1
1, 274, 419, 312
2, 141, 302, 142
3, 144, 302, 141
4, 279, 335, 281
5, 311, 315, 280
6, 75, 140, 102
7, 274, 312, 291
8, 140, 141, 102
9, 265, 436, 434
10, 295, 359, 216
11, 434, 436, 290
12, 374, 430, 109
13, 116, 330, 329
14, 347, 374, 109
15, 73, 408, 72
16, 279, 444, 335
17, 225, 318, 291
18, 271, 406, 307
19, 311, 447, 315
20, 234, 405, 68
21, 411, 441, 404
22, 365, 421, 314
23, 142, 297, 296
24, 403, 414, 198
25, 42, 366, 292
26, 318, 412, 230
27, 292, 459, 42
28, 125, 421, 365
29, 69, 234, 68
30, 102, 415, 74
31, 368, 414, 403
32, 283, 430, 374
33, 342, 449, 349
34, 291, 319, 225
35, 168, 383, 303
36, 295, 469, 359
37, 364, 365, 243
38, 45, 430, 305
39, 74, 415, 217
40, 116, 429, 330
41, 254, 408, 73
42, 203, 304, 187
43, 185, 308, 203
44, 243, 473, 364
45, 116, 329, 29
46, 254, 446, 408
47, 212, 433, 388
48, 116, 376, 309
49, 104, 231, 67
50, 66, 231, 101
51, 125, 364, 363
52, 130, 360, 127
53, 70, 233, 100
54, 393, 441, 373
55, 44, 305, 114
56, 307, 422, 271
57, 104, 270, 231
58, 231, 232, 101
59, 187, 304, 189
60, 322, 387, 331
61, 171, 383, 168
62, 175, 301, 176
63, 30, 376, 116
64, 306, 415, 296
65, 316, 412, 318
66, 249, 306, 296
67, 233, 277, 100
68, 307, 406, 308
69, 257, 424, 353
70, 125, 363, 121
71, 322, 460, 387
72, 6, 363, 233
73, 317, 416, 372
74, 404, 441, 157
75, 55, 477, 357
76, 286, 372, 245
77, 312, 319, 291
78, 338, 413, 278
79, 296, 415, 142
80, 358, 409, 106
81, 217, 415, 306
82, 268, 409, 358
83, 152, 319, 154
84, 278, 445, 338
85, 68, 405, 104
86, 157, 441, 393
87, 298, 439, 263
88, 355, 367, 354
89, 127, 360, 124
90, 305, 430, 283
91, 142, 302, 297
92, 160, 319, 312
93, 341, 380, 351
94, 362, 446, 254
95, 200, 299, 228
96, 6, 470, 363
97, 372, 416, 260
98, 45, 305, 44
99, 225, 319, 152
100, 350, 369, 345
101, 341, 457, 380
102, 202, 367, 355
103, 154, 319, 160
104, 28, 329, 327
105, 276, 441, 411
106, 313, 360, 130
107, 120, 440, 377
108, 249, 426, 306
109, 198, 433, 395
110, 216, 445, 295
111, 343, 449, 342
112, 340, 344, 343
113, 266, 318, 230
114, 55, 357, 110
115, 345, 369, 205
116, 329, 330, 328
117, 243, 365, 356
118, 377, 440, 284
119, 101, 266, 230
120, 308, 418, 203
121, 56, 477, 55
122, 312, 419, 175
123, 100, 277, 241
124, 245, 372, 260
125, 350, 357, 262
126, 344, 345, 343
127, 197, 423, 392
128, 321, 325, 324
129, 200, 228, 227
130, 28, 327, 27
131, 189, 304, 192
132, 179, 229, 181
133, 304, 385, 299
134, 395, 433, 212
135, 327, 329, 328
136, 183, 308, 185
137, 59, 375, 300
138, 29, 329, 28
139, 342, 349, 348
140, 263, 438, 298
141, 249, 296, 248
142, 316, 318, 225
143, 414, 433, 198
144, 143, 316, 145
145, 175, 419, 301
146, 307, 308, 183
147, 194, 299, 200
148, 176, 301, 179
149, 229, 307, 181
150, 310, 402, 14
151, 236, 248, 207
152, 120, 377, 62
153, 226, 314, 313
154, 323, 401, 333
155, 134, 313, 130
156, 339, 344, 340
157, 192, 304, 299
158, 236, 249, 248
159, 112, 338, 337
160, 200, 227, 201
161, 347, 399, 374
162, 110, 344, 339
163, 320, 321, 214
164, 194, 200, 196
165, 181, 307, 183
166, 110, 350, 344
167, 320, 325, 321
168, 306, 426, 362
169, 114, 366, 43
170, 119, 333, 332
171, 356, 365, 314
172, 160, 312, 162
173, 162, 312, 175
174, 192, 299, 194
175, 125, 365, 364
176, 300, 476, 59
177, 265, 434, 355
178, 262, 357, 293
179, 353, 439, 257
180, 303, 466, 168
181, 145, 316, 148
182, 291, 318, 266
183, 226, 313, 139
184, 112, 337, 12
185, 162, 175, 164
186, 110, 339, 54
187, 333, 335, 332
188, 221, 398, 368
189, 148, 316, 225
190, 354, 356, 226
191, 325, 398, 324
192, 105, 326, 325
193, 139, 313, 134
194, 110, 357, 350
195, 321, 324, 323
196, 218, 354, 226
197, 262, 369, 350
198, 24, 331, 23
199, 140, 143, 141
200, 176, 179, 178
201, 299, 385, 228
202, 14, 462, 310
203, 340, 343, 342
204, 185, 203, 187
205, 179, 301, 229
206, 179, 181, 180
207, 105, 325, 320
208, 314, 421, 360
209, 302, 455, 303
210, 346, 347, 109
211, 252, 396, 388
212, 39, 317, 213
213, 25, 320, 214
214, 119, 332, 20
215, 113, 447, 311
216, 117, 334, 34
217, 296, 297, 248
218, 388, 433, 429
219, 16, 113, 15
220, 44, 114, 43
221, 30, 116, 29
222, 286, 451, 372
223, 227, 473, 243
224, 218, 226, 139
225, 19, 107, 18
226, 41, 108, 40
227, 208, 236, 207
228, 392, 423, 324
229, 27, 105, 26
230, 264, 336, 210
231, 33, 106, 32
232, 107, 315, 18
233, 339, 340, 215
234, 118, 346, 48
235, 200, 201, 196
236, 58, 115, 57
237, 388, 396, 212
238, 348, 349, 347
239, 175, 176, 164
240, 332, 335, 107
241, 108, 317, 40
242, 55, 110, 54
243, 47, 109, 46
244, 13, 112, 12
245, 61, 111, 60
246, 19, 332, 107
247, 206, 207, 171
248, 105, 320, 26
249, 458, 465, 286
250, 33, 334, 106
251, 451, 465, 361
252, 277, 407, 241
253, 27, 327, 105
254, 321, 323, 322
255, 207, 383, 171
256, 227, 243, 201
257, 5, 140, 75
258, 264, 352, 336
259, 118, 348, 346
260, 148, 225, 152
261, 47, 346, 109
262, 368, 398, 326
263, 354, 367, 356
264, 340, 342, 341
265, 361, 465, 378
266, 149, 373, 155
267, 359, 469, 379
268, 247, 424, 257
269, 189, 192, 191
270, 263, 264, 210
271, 327, 328, 326
272, 345, 410, 343
273, 285, 458, 286
274, 181, 183, 182
275, 11, 337, 216
276, 53, 339, 215
277, 314, 360, 313
278, 192, 194, 193
279, 305, 435, 114
280, 52, 351, 51
281, 226, 356, 314
282, 236, 336, 272
283, 179, 180, 178
284, 336, 352, 272
285, 12, 337, 11
286, 54, 339, 53
287, 214, 331, 24
288, 114, 428, 366
289, 321, 322, 214
290, 334, 358, 106
291, 335, 444, 107
292, 304, 442, 385
293, 344, 350, 345
294, 18, 315, 17
295, 346, 348, 347
296, 216, 359, 10
297, 213, 361, 38
298, 183, 185, 184
299, 236, 272, 249
300, 154, 160, 159
301, 297, 383, 248
302, 26, 320, 25
303, 358, 458, 285
304, 40, 317, 39
305, 20, 332, 19
306, 160, 162, 161
307, 34, 334, 33
308, 340, 341, 215
309, 263, 439, 264
310, 14, 402, 13
311, 11, 216, 10
312, 242, 354, 218
313, 25, 214, 24
314, 48, 346, 47
315, 38, 361, 37
316, 53, 215, 52
317, 455, 466, 303
318, 10, 359, 9
319, 39, 213, 38
320, 208, 336, 236
321, 206, 208, 207
322, 35, 117, 34
323, 21, 119, 20
324, 49, 118, 48
325, 31, 376, 30
326, 63, 120, 62
327, 309, 429, 116
328, 108, 416, 317
329, 105, 327, 326
330, 461, 464, 270
331, 215, 351, 52
332, 141, 142, 102
333, 328, 368, 326
334, 203, 442, 304
335, 194, 196, 195
336, 192, 193, 191
337, 370, 376, 31
338, 290, 436, 311
339, 315, 447, 17
340, 328, 414, 368
341, 138, 139, 134
342, 269, 376, 370
343, 136, 391, 247
344, 181, 182, 180
345, 317, 372, 213
346, 303, 383, 297
347, 32, 370, 31
348, 324, 398, 392
349, 43, 366, 42
350, 265, 355, 242
351, 335, 401, 281
352, 264, 353, 352
353, 242, 355, 354
354, 338, 445, 337
355, 176, 178, 177
356, 136, 247, 239
357, 287, 461, 301
358, 323, 423, 401
359, 412, 474, 230
360, 162, 164, 163
361, 155, 373, 169
362, 16, 447, 113
363, 170, 171, 168
364, 169, 273, 238
365, 322, 331, 214
366, 204, 218, 139
367, 185, 187, 186
368, 167, 168, 156
369, 285, 454, 358
370, 341, 351, 215
371, 65, 474, 5
372, 145, 148, 147
373, 224, 290, 280
374, 111, 375, 60
375, 301, 419, 287
376, 15, 462, 14
377, 241, 407, 294
378, 273, 276, 275
379, 106, 370, 32
380, 333, 460, 323
381, 183, 184, 182
382, 64, 379, 63
383, 36, 378, 35
384, 199, 396, 252
385, 62, 377, 61
386, 50, 380, 49
387, 224, 371, 290
388, 205, 206, 171
389, 160, 161, 159
390, 247, 257, 256
391, 194, 195, 193
392, 22, 387, 21
393, 210, 336, 208
394, 143, 412, 316
395, 356, 367, 243
396, 259, 265, 242
397, 209, 210, 208
398, 205, 410, 345
399, 185, 186, 184
400, 219, 242, 218
401, 60, 375, 59
402, 199, 252, 251
403, 104, 271, 270
404, 294, 442, 418
405, 261, 263, 210
406, 126, 132, 128
407, 302, 303, 297
408, 232, 266, 101
409, 390, 413, 222
410, 257, 298, 258
411, 245, 260, 174
412, 176, 177, 164
413, 333, 401, 335
414, 162, 163, 161
415, 187, 189, 188
416, 138, 204, 139
417, 189, 191, 190
418, 61, 377, 111
419, 295, 445, 278
420, 72, 103, 71
421, 170, 205, 171
422, 75, 102, 74
423, 201, 202, 196
424, 248, 383, 207
425, 103, 121, 71
426, 129, 130, 127
427, 279, 281, 223
428, 349, 399, 347
429, 290, 311, 280
430, 169, 373, 273
431, 255, 413, 390
432, 228, 437, 227
433, 366, 428, 282
434, 247, 256, 239
435, 362, 426, 132
436, 167, 170, 168
437, 233, 363, 288
438, 233, 288, 277
439, 68, 104, 67
440, 326, 398, 325
441, 411, 428, 276
442, 35, 378, 117
443, 252, 309, 269
444, 273, 275, 238
445, 148, 152, 151
446, 63, 379, 120
447, 70, 100, 69
448, 66, 101, 65
449, 243, 367, 201
450, 49, 380, 118
451, 240, 255, 137
452, 267, 278, 255
453, 315, 444, 280
454, 229, 422, 307
455, 294, 407, 385
456, 211, 253, 246
457, 209, 262, 261
458, 196, 371, 195
459, 178, 199, 177
460, 46, 430, 45
461, 220, 285, 245
462, 206, 209, 208
463, 140, 412, 143
464, 209, 261, 210
465, 131, 136, 135
466, 204, 219, 218
467, 59, 476, 58
468, 205, 369, 206
469, 285, 286, 245
470, 240, 284, 267
471, 148, 151, 147
472, 131, 134, 130
473, 211, 235, 158
474, 219, 259, 242
475, 135, 138, 134
476, 257, 258, 256
477, 136, 239, 137
478, 163, 173, 165
479, 21, 387, 119
480, 187, 188, 186
481, 191, 197, 190
482, 154, 159, 158
483, 195, 224, 223
484, 42, 459, 41
485, 144, 455, 302
486, 189, 190, 188
487, 298, 300, 258
488, 23, 448, 2
489, 2, 448, 22
490, 173, 220, 174
491, 300, 375, 258
492, 195, 223, 193
493, 74, 217, 73
494, 149, 150, 146
495, 219, 289, 259
496, 167, 172, 170
497, 190, 221, 188
498, 267, 295, 278
499, 220, 245, 174
500, 262, 293, 261
501, 334, 458, 358
502, 380, 457, 118
503, 244, 405, 234
504, 224, 279, 223
505, 251, 268, 250
506, 323, 460, 322
507, 57, 456, 56
508, 163, 165, 161
509, 166, 167, 156
510, 138, 222, 204
511, 155, 156, 150
512, 252, 269, 251
513, 106, 409, 370
514, 177, 384, 164
515, 330, 414, 328
516, 199, 250, 177
517, 224, 280, 279
518, 159, 211, 158
519, 199, 251, 250
520, 246, 282, 235
521, 240, 267, 255
522, 173, 174, 165
523, 4, 450, 50
524, 51, 450, 4
525, 239, 240, 137
526, 275, 283, 238
527, 67, 231, 66
528, 6, 233, 70
529, 202, 371, 196
530, 143, 145, 144
531, 182, 212, 180
532, 128, 129, 127
533, 136, 137, 135
534, 152, 154, 153
535, 143, 144, 141
536, 373, 441, 273
537, 211, 394, 253
538, 348, 457, 342
539, 169, 238, 237
540, 449, 467, 349
541, 13, 402, 112
542, 211, 246, 235
543, 282, 411, 235
544, 131, 135, 134
545, 238, 374, 237
546, 122, 125, 121
547, 164, 384, 163
548, 275, 305, 283
549, 155, 169, 166
550, 289, 310, 259
551, 206, 369, 209
552, 129, 131, 130
553, 126, 127, 124
554, 309, 376, 269
555, 195, 371, 224
556, 103, 122, 121
557, 128, 133, 129
558, 186, 198, 184
559, 352, 463, 272
560, 145, 147, 146
561, 201, 367, 202
562, 126, 128, 127
563, 154, 158, 153
564, 246, 292, 282
565, 123, 126, 124
566, 292, 366, 282
567, 209, 369, 262
568, 230, 474, 65
569, 155, 166, 156
570, 132, 382, 128
571, 103, 123, 122
572, 232, 287, 274
573, 372, 451, 213
574, 169, 237, 166
575, 168, 466, 156
576, 252, 388, 309
577, 418, 442, 203
578, 149, 155, 150
579, 311, 436, 113
580, 123, 124, 122
581, 153, 157, 151
582, 250, 384, 177
583, 147, 149, 146
584, 9, 452, 1
585, 1, 452, 64
586, 37, 453, 3
587, 3, 453, 36
588, 101, 230, 65
589, 281, 386, 223
590, 145, 146, 144
591, 100, 234, 69
592, 152, 153, 151
593, 306, 362, 254
594, 163, 384, 173
595, 191, 386, 197
596, 301, 461, 229
597, 283, 374, 238
598, 193, 386, 191
599, 368, 403, 221
600, 253, 389, 246
601, 255, 390, 137
602, 428, 435, 276
603, 217, 254, 73
604, 132, 446, 362
605, 256, 381, 239
606, 387, 460, 119
607, 240, 381, 284
608, 108, 459, 389
609, 260, 420, 174
610, 280, 444, 279
611, 149, 393, 373
612, 374, 399, 237
613, 126, 446, 132
614, 5, 474, 140
615, 298, 438, 300
616, 159, 394, 211
617, 178, 396, 199
618, 170, 410, 205
619, 239, 381, 240
620, 161, 394, 159
621, 223, 386, 193
622, 392, 398, 221
623, 138, 390, 222
624, 406, 418, 308
625, 246, 389, 292
626, 112, 432, 338
627, 131, 391, 136
628, 363, 364, 288
629, 167, 397, 172
630, 244, 418, 406
631, 180, 396, 178
632, 135, 390, 138
633, 184, 395, 182
634, 241, 244, 234
635, 128, 382, 133
636, 274, 291, 266
637, 235, 404, 158
638, 370, 409, 269
639, 190, 392, 221
640, 251, 409, 268
641, 197, 392, 190
642, 165, 394, 161
643, 324, 423, 323
644, 220, 454, 285
645, 217, 306, 254
646, 269, 409, 251
647, 241, 294, 244
648, 219, 400, 289
649, 232, 274, 266
650, 137, 390, 135
651, 360, 421, 124
652, 133, 391, 129
653, 166, 397, 167
654, 342, 457, 341
655, 355, 434, 202
656, 172, 410, 170
657, 129, 391, 131
658, 289, 402, 310
659, 237, 397, 166
660, 237, 399, 397
661, 204, 400, 219
662, 212, 396, 180
663, 257, 439, 298
664, 222, 400, 204
665, 382, 463, 352
666, 221, 403, 188
667, 104, 405, 271
668, 151, 393, 147
669, 456, 477, 56
670, 72, 408, 103
671, 278, 413, 255
672, 389, 459, 292
673, 100, 241, 234
674, 244, 406, 405
675, 182, 395, 212
676, 198, 395, 184
677, 173, 417, 220
678, 147, 393, 149
679, 287, 464, 461
680, 111, 427, 375
681, 375, 427, 258
682, 188, 403, 186
683, 157, 393, 151
684, 389, 416, 108
685, 410, 449, 343
686, 422, 461, 270
687, 250, 417, 384
688, 158, 404, 153
689, 289, 432, 402
690, 186, 403, 198
691, 394, 420, 253
692, 384, 417, 173
693, 391, 424, 247
694, 146, 455, 144
695, 277, 437, 407
696, 153, 404, 157
697, 103, 408, 123
698, 310, 425, 259
699, 293, 431, 261
700, 429, 433, 330
701, 109, 430, 46
702, 268, 417, 250
703, 71, 470, 6
704, 272, 426, 249
705, 165, 420, 394
706, 275, 435, 305
707, 235, 411, 404
708, 331, 448, 23
709, 142, 415, 102
710, 267, 440, 295
711, 124, 421, 122
712, 117, 458, 334
713, 385, 407, 228
714, 256, 427, 381
715, 282, 428, 411
716, 202, 434, 371
717, 107, 444, 315
718, 287, 419, 274
719, 402, 432, 112
720, 174, 420, 165
721, 358, 454, 268
722, 438, 476, 300
723, 294, 418, 244
724, 140, 474, 412
725, 113, 462, 15
726, 259, 425, 265
727, 41, 459, 108
728, 117, 465, 458
729, 337, 445, 216
730, 293, 456, 431
731, 408, 446, 123
732, 273, 441, 276
733, 371, 434, 290
734, 351, 450, 51
735, 122, 421, 125
736, 115, 456, 57
737, 58, 476, 115
738, 258, 427, 256
739, 405, 406, 271
740, 271, 422, 270
741, 261, 431, 263
742, 253, 472, 389
743, 36, 453, 378
744, 64, 452, 379
745, 22, 448, 387
746, 276, 435, 275
747, 353, 475, 352
748, 119, 460, 333
749, 213, 451, 361
750, 50, 450, 380
751, 407, 437, 228
752, 17, 447, 16
753, 232, 464, 287
754, 197, 443, 423
755, 427, 468, 381
756, 264, 439, 353
757, 359, 452, 9
758, 361, 453, 37
759, 133, 424, 391
760, 363, 470, 121
761, 118, 457, 348
762, 121, 470, 71
763, 349, 467, 399
764, 437, 473, 227
765, 400, 432, 289
766, 426, 463, 132
767, 385, 442, 294
768, 401, 443, 281
769, 388, 429, 309
770, 288, 437, 277
771, 270, 464, 231
772, 284, 440, 267
773, 379, 452, 359
774, 378, 453, 361
775, 123, 446, 126
776, 231, 464, 232
777, 281, 443, 386
778, 150, 455, 146
779, 389, 472, 416
780, 380, 450, 351
781, 431, 438, 263
782, 431, 456, 115
783, 387, 448, 331
784, 399, 467, 397
785, 386, 443, 197
786, 352, 475, 382
787, 150, 466, 455
788, 133, 475, 424
789, 424, 475, 353
790, 284, 468, 377
791, 357, 477, 293
792, 156, 466, 150
793, 377, 468, 111
794, 330, 433, 414
795, 413, 471, 222
796, 338, 471, 413
797, 260, 472, 420
798, 172, 467, 449
799, 378, 465, 117
800, 111, 468, 427
801, 425, 436, 265
802, 115, 476, 438
803, 379, 469, 120
804, 132, 463, 382
805, 172, 449, 410
806, 432, 471, 338
807, 440, 469, 295
808, 417, 454, 220
809, 114, 435, 428
810, 310, 462, 425
811, 423, 443, 401
812, 397, 467, 172
813, 113, 436, 425
814, 381, 468, 284
815, 288, 473, 437
816, 115, 438, 431
817, 364, 473, 288
818, 268, 454, 417
819, 400, 471, 432
820, 416, 472, 260
821, 222, 471, 400
822, 382, 475, 133
823, 286, 465, 451
824, 420, 472, 253
825, 272, 463, 426
826, 229, 461, 422
827, 425, 462, 113
828, 293, 477, 456
829, 120, 469, 440
830, 487, 512, 494
831, 77, 530, 76
832, 487, 516, 514
833, 487, 542, 516
834, 506, 529, 505
835, 68, 548, 501
836, 511, 522, 494
837, 515, 534, 527
838, 498, 537, 536
839, 512, 514, 513
840, 487, 514, 512
841, 513, 514, 495
842, 74, 517, 75
843, 489, 505, 503
844, 515, 527, 525
845, 482, 540, 537
846, 496, 498, 488
847, 70, 488, 6
848, 5, 489, 65
849, 68, 490, 69
850, 66, 491, 67
851, 517, 525, 506
852, 6, 521, 71
853, 75, 524, 5
854, 481, 530, 77
855, 503, 505, 504
856, 516, 534, 514
857, 71, 521, 510
858, 71, 510, 492
859, 497, 498, 496
860, 67, 548, 68
861, 71, 492, 72
862, 543, 544, 478
863, 495, 515, 74
864, 91, 522, 90
865, 518, 543, 478
866, 72, 513, 73
867, 73, 495, 74
868, 490, 497, 496
869, 73, 513, 495
870, 492, 510, 509
871, 503, 504, 491
872, 498, 536, 499
873, 497, 538, 498
874, 505, 531, 504
875, 526, 528, 483
876, 68, 501, 490
877, 479, 544, 543
878, 494, 512, 511
879, 509, 511, 492
880, 76, 530, 483
881, 514, 534, 515
882, 70, 496, 488
883, 492, 513, 72
884, 490, 496, 69
885, 489, 503, 65
886, 479, 543, 520
887, 66, 503, 491
888, 96, 535, 95
889, 537, 538, 482
890, 520, 532, 479
891, 478, 519, 518
892, 527, 534, 485
893, 509, 522, 511
894, 69, 496, 70
895, 525, 549, 526
896, 65, 503, 66
897, 515, 525, 517
898, 509, 510, 508
899, 489, 506, 505
900, 88, 507, 8
901, 485, 533, 527
902, 537, 540, 484
903, 491, 548, 67
904, 98, 533, 97
905, 497, 546, 539
906, 511, 513, 492
907, 504, 520, 491
908, 517, 524, 75
909, 490, 500, 497
910, 534, 535, 485
911, 488, 521, 6
912, 481, 531, 530
913, 498, 499, 488
914, 506, 524, 517
915, 500, 546, 497
916, 491, 520, 502
917, 5, 524, 489
918, 501, 518, 500
919, 483, 529, 526
920, 481, 541, 532
921, 532, 541, 479
922, 79, 541, 78
923, 493, 523, 509
924, 494, 522, 91
925, 525, 526, 506
926, 95, 542, 94
927, 519, 547, 480
928, 538, 539, 482
929, 481, 532, 531
930, 8, 484, 87
931, 76, 483, 7
932, 86, 482, 85
933, 84, 480, 83
934, 78, 481, 77
935, 82, 478, 81
936, 80, 479, 79
937, 514, 515, 495
938, 85, 545, 84
939, 502, 518, 501
940, 90, 523, 89
941, 539, 545, 482
942, 536, 537, 484
943, 480, 545, 539
944, 87, 540, 86
945, 489, 524, 506
946, 81, 544, 80
947, 83, 547, 82
948, 94, 487, 93
949, 7, 528, 99
950, 99, 486, 98
951, 97, 485, 96
952, 8, 507, 484
953, 485, 535, 96
954, 490, 501, 500
955, 92, 494, 91
956, 480, 546, 519
957, 483, 530, 529
958, 539, 546, 480
959, 78, 541, 481
960, 479, 541, 79
961, 484, 540, 87
962, 86, 540, 482
963, 89, 493, 88
964, 482, 545, 85
965, 486, 533, 98
966, 84, 545, 480
967, 97, 533, 485
968, 80, 544, 479
969, 478, 544, 81
970, 483, 528, 7
971, 480, 547, 83
972, 478, 547, 519
973, 82, 547, 478
974, 535, 542, 95
975, 530, 531, 505
976, 508, 536, 507
977, 528, 549, 486
978, 497, 539, 538
979, 493, 509, 508
980, 516, 535, 534
981, 94, 542, 487
982, 99, 528, 486
983, 499, 521, 488
984, 508, 510, 499
985, 493, 507, 88
986, 499, 536, 508
987, 518, 519, 500
988, 531, 532, 504
989, 529, 530, 505
990, 504, 532, 520
991, 507, 536, 484
992, 519, 546, 500
993, 502, 543, 518
994, 522, 523, 90
995, 510, 521, 499
996, 512, 513, 511
997, 89, 523, 493
998, 526, 549, 528
999, 502, 548, 491
1000, 520, 543, 502
1001, 501, 548, 502
1002, 493, 508, 507
1003, 526, 529, 506
1004, 498, 538, 537
1005, 486, 549, 533
1006, 527, 549, 525
1007, 533, 549, 527
1008, 516, 542, 535
1009, 509, 523, 522
1010, 515, 517, 74
1011, 93, 487, 92
1012, 487, 494, 92
1013, 98, 591, 99
1014, 582, 597, 552
1015, 582, 605, 597
1016, 574, 596, 557
1017, 554, 591, 98
1018, 576, 591, 589
1019, 81, 585, 553
1020, 574, 608, 596
1021, 80, 585, 81
1022, 589, 591, 554
1023, 99, 591, 560
1024, 589, 595, 559
1025, 559, 605, 589
1026, 83, 588, 84
1027, 84, 588, 556
1028, 578, 579, 564
1029, 565, 578, 564
1030, 97, 554, 98
1031, 89, 557, 90
1032, 572, 573, 568
1033, 568, 578, 565
1034, 576, 577, 566
1035, 95, 559, 96
1036, 569, 572, 568
1037, 93, 552, 94
1038, 91, 558, 92
1039, 573, 578, 568
1040, 567, 568, 565
1041, 569, 580, 572
1042, 577, 581, 566
1043, 577, 582, 581
1044, 563, 576, 566
1045, 567, 569, 568
1046, 78, 555, 79
1047, 7, 551, 76
1048, 81, 553, 82
1049, 563, 565, 564
1050, 571, 580, 569
1051, 84, 556, 85
1052, 570, 571, 569
1053, 566, 567, 565
1054, 580, 583, 572
1055, 563, 564, 562
1056, 567, 570, 569
1057, 563, 566, 565
1058, 570, 575, 574
1059, 566, 581, 567
1060, 570, 574, 571
1061, 567, 581, 570
1062, 570, 581, 575
1063, 581, 582, 575
1064, 87, 550, 8
1065, 561, 576, 563
1066, 561, 563, 562
1067, 561, 591, 576
1068, 557, 593, 574
1069, 579, 607, 555
1070, 588, 600, 587
1071, 573, 584, 578
1072, 561, 562, 551
1073, 76, 586, 77
1074, 551, 586, 76
1075, 555, 590, 579
1076, 553, 585, 584
1077, 556, 587, 583
1078, 583, 587, 572
1079, 552, 602, 582
1080, 585, 607, 579
1081, 579, 590, 564
1082, 574, 593, 571
1083, 578, 584, 579
1084, 584, 585, 579
1085, 587, 600, 573
1086, 558, 608, 602
1087, 597, 605, 559
1088, 562, 586, 551
1089, 572, 587, 573
1090, 562, 590, 586
1091, 556, 588, 587
1092, 593, 594, 592
1093, 560, 561, 551
1094, 558, 602, 598
1095, 599, 601, 583
1096, 576, 589, 577
1097, 8, 594, 88
1098, 564, 590, 562
1099, 593, 604, 594
1100, 550, 594, 8
1101, 590, 603, 586
1102, 571, 592, 580
1103, 99, 560, 7
1104, 97, 595, 554
1105, 573, 600, 584
1106, 557, 596, 90
1107, 559, 595, 96
1108, 7, 560, 551
1109, 95, 597, 559
1110, 91, 596, 558
1111, 552, 597, 94
1112, 93, 598, 552
1113, 558, 598, 92
1114, 96, 595, 97
1115, 90, 596, 91
1116, 94, 597, 95
1117, 92, 598, 93
1118, 86, 599, 87
1119, 554, 595, 589
1120, 582, 602, 575
1121, 583, 601, 556
1122, 589, 605, 577
1123, 556, 601, 85
1124, 87, 599, 550
1125, 85, 601, 86
1126, 89, 604, 557
1127, 77, 603, 78
1128, 583, 609, 599
1129, 82, 606, 83
1130, 560, 591, 561
1131, 79, 607, 80
1132, 596, 608, 558
1133, 88, 604, 89
1134, 78, 603, 555
1135, 80, 607, 585
1136, 577, 605, 582
1137, 553, 606, 82
1138, 584, 600, 553
1139, 555, 607, 79
1140, 83, 606, 588
1141, 580, 609, 583
1142, 575, 608, 574
1143, 592, 609, 580
1144, 550, 609, 592
1145, 602, 608, 575
1146, 588, 606, 600
1147, 586, 603, 77
1148, 571, 593, 592
1149, 592, 594, 550
1150, 555, 603, 590
1151, 557, 604, 593
1152, 86, 601, 599
1153, 598, 602, 552
1154, 594, 604, 88
1155, 600, 606, 553
1156, 599, 609, 550
**
** Node sets +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Element sets ++++++++++++++++++++++++++++++++++++++++++++
**
*Elset, Elset=Element_Set-1
1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 1024, 1025, 1026, 1027, 1028, 
1029, 1030, 1031, 1032, 1033, 1034, 1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 1043, 1044, 
1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 1054, 1055, 1056, 1057, 1058, 1059, 1060, 
1061, 1062, 1063, 1064, 1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 1073, 1074, 1075, 1076, 
1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 
1093, 1094, 1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 1105, 1106, 1107, 1108, 
1109, 1110, 1111, 1112, 1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 
1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 
1141, 1142, 1143, 1144, 1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 1155, 1156
**
** Surfaces ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Physical constants ++++++++++++++++++++++++++++++++++++++
**
**
** Materials +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Sections ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Pre-tension sections ++++++++++++++++++++++++++++++++++++
**
**
** Constraints +++++++++++++++++++++++++++++++++++++++++++++
**
**
** Surface interactions ++++++++++++++++++++++++++++++++++++
**
**
** Contact pairs +++++++++++++++++++++++++++++++++++++++++++
**
**
** Amplitudes ++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Initial conditions ++++++++++++++++++++++++++++++++++++++
**
**
** Steps +++++++++++++++++++++++++++++++++++++++++++++++++++
**
