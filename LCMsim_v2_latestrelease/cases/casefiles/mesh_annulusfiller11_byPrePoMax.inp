**
** Heading +++++++++++++++++++++++++++++++++++++++++++++++++
**
*Heading
Hash: KLtYba1k, Date: 01/03/2024, Unit system: M_KG_S_C
**
** Nodes +++++++++++++++++++++++++++++++++++++++++++++++++++
**
*Node
1, 1.00778216E-001, 7.15293708E-003, 2.85008655E-002
2, 8.73485983E-002, 7.15190496E-003, 2.85011092E-002
3, 8.63823303E-002, -9.97639358E-003, 2.84996659E-002
4, 3.55363951E-002, -9.90693305E-003, 2.85010524E-002
5, 3.19558707E-002, 7.15081701E-003, 2.85023136E-002
6, 1.69124829E-002, 7.15452517E-003, 2.85019493E-002
7, 1.69124835E-002, -1.40459705E-002, 2.85015504E-002
8, 1.00778196E-001, -1.40459705E-002, 2.84992455E-002
9, 1.16616603E-001, 9.44938514E-002, 3.78003218E-001
10, 1.42363174E-001, 9.44942337E-002, 3.78001838E-001
11, 4.08105807E-002, 9.44949966E-002, 3.78000401E-001
12, 1.52517723E-002, 9.45043840E-002, 3.77999268E-001
13, 1.06842139E-001, -9.98376876E-003, 3.78003537E-001
14, 5.72890077E-002, -9.92535577E-003, 3.78003628E-001
15, 8.71553296E-002, 3.72758422E-003, 2.85006365E-002
16, 8.69620751E-002, 3.01142347E-004, 2.85003956E-002
17, 8.67688206E-002, -3.12529953E-003, 2.85001547E-002
18, 8.65755661E-002, -6.55174140E-003, 2.84999138E-002
19, 7.62132571E-002, -9.96101959E-003, 2.84999525E-002
20, 6.60441978E-002, -9.94744095E-003, 2.85002321E-002
21, 5.58751385E-002, -9.93386231E-003, 2.85005116E-002
22, 4.57060792E-002, -9.92028367E-003, 2.85007912E-002
23, 3.48207295E-002, -6.49821006E-003, 2.85013804E-002
24, 3.41044444E-002, -3.08574364E-003, 2.85016900E-002
25, 3.33881592E-002, 3.26722772E-004, 2.85019996E-002
26, 3.26718741E-002, 3.73918919E-003, 2.85023092E-002
27, 1.69124832E-002, -3.44572265E-003, 2.85017499E-002
28, 3.08901022E-002, -1.40459705E-002, 2.85011662E-002
29, 4.48677209E-002, -1.40459705E-002, 2.85007821E-002
30, 5.88453396E-002, -1.40459705E-002, 2.85003980E-002
31, 7.28229583E-002, -1.40459705E-002, 2.85000138E-002
32, 8.68005770E-002, -1.40459705E-002, 2.84996297E-002
33, 1.00778206E-001, -3.44651670E-003, 2.85000555E-002
34, 1.17688185E-001, 9.09822543E-002, 3.63930859E-001
35, 1.18728712E-001, 8.74646643E-002, 3.49857388E-001
36, 1.19712123E-001, 8.39461158E-002, 3.35780036E-001
37, 1.20588692E-001, 8.04259345E-002, 3.21696070E-001
38, 1.21333452E-001, 7.69039930E-002, 3.07604959E-001
39, 1.21918559E-001, 7.33803237E-002, 2.93506811E-001
40, 1.22298819E-001, 6.98550504E-002, 2.79402086E-001
41, 1.22447859E-001, 6.63288086E-002, 2.65293308E-001
42, 1.22346449E-001, 6.28025227E-002, 2.51184158E-001
43, 1.21957823E-001, 5.92774659E-002, 2.37079703E-001
44, 1.21283706E-001, 5.57549934E-002, 2.22985366E-001
45, 1.20328778E-001, 5.22363813E-002, 2.08906257E-001
46, 1.19112109E-001, 4.87225741E-002, 1.94846168E-001
47, 1.17598902E-001, 4.52156199E-002, 1.80813267E-001
48, 1.15815618E-001, 4.17161507E-002, 1.66810104E-001
49, 1.13772182E-001, 3.82251221E-002, 1.52840509E-001
50, 1.11456936E-001, 3.47441189E-002, 1.38910813E-001
51, 1.08926930E-001, 3.12719345E-002, 1.25016234E-001
52, 1.06200194E-001, 2.78085612E-002, 1.11156754E-001
53, 1.03292879E-001, 2.43538401E-002, 9.73317516E-002
54, 1.00255431E-001, 2.09057389E-002, 8.35331334E-002
55, 9.71161642E-002, 1.74630020E-002, 6.97558980E-002
56, 9.39113717E-002, 1.40238406E-002, 5.59929173E-002
57, 9.06432980E-002, 1.05881828E-002, 4.22439048E-002
58, 1.04716784E-001, 1.05621205E-002, 4.21447195E-002
59, 1.08627903E-001, 1.39731651E-002, 5.57959987E-002
60, 1.12483780E-001, 1.73879125E-002, 6.94620498E-002
61, 1.16255939E-001, 2.08081632E-002, 8.31500539E-002
62, 1.19914868E-001, 2.42356524E-002, 9.68669309E-002
63, 1.23429647E-001, 2.76720164E-002, 1.10619203E-001
64, 1.26767581E-001, 3.11187546E-002, 1.24412845E-001
65, 1.29891740E-001, 3.45772778E-002, 1.38253470E-001
66, 1.32762643E-001, 3.80487156E-002, 1.52145570E-001
67, 1.35360263E-001, 4.15328289E-002, 1.66088171E-001
68, 1.37669770E-001, 4.50288963E-002, 1.80078375E-001
69, 1.39680757E-001, 4.85358437E-002, 1.94111878E-001
70, 1.41390589E-001, 5.20522244E-002, 2.08182889E-001
71, 1.42800620E-001, 5.55764722E-002, 2.22285143E-001
72, 1.43913403E-001, 5.91070247E-002, 2.36412391E-001
73, 1.44733160E-001, 6.26423447E-002, 2.50558486E-001
74, 1.45265719E-001, 6.61809478E-002, 2.64717493E-001
75, 1.45518727E-001, 6.97214261E-002, 2.78883785E-001
76, 1.45520745E-001, 7.32625044E-002, 2.93052284E-001
77, 1.45312400E-001, 7.68032693E-002, 3.07219365E-001
78, 1.44929843E-001, 8.03432193E-002, 3.21383050E-001
79, 1.44408701E-001, 8.38821605E-002, 3.35542593E-001
80, 1.43784106E-001, 8.74201416E-002, 3.49698213E-001
81, 1.43090784E-001, 9.09573863E-002, 3.63850833E-001
82, 3.46171526E-002, 1.06101622E-002, 4.23462111E-002
83, 3.72507227E-002, 1.40699393E-002, 5.61948349E-002
84, 3.98279773E-002, 1.75322301E-002, 7.00534122E-002
85, 4.23199338E-002, 2.09982216E-002, 8.39266383E-002
86, 4.46966137E-002, 2.44690145E-002, 9.78188611E-002
87, 4.69266906E-002, 2.79455764E-002, 1.11733895E-001
88, 4.89771417E-002, 3.14287020E-002, 1.25674857E-001
89, 5.08108209E-002, 3.49190053E-002, 1.39644135E-001
90, 5.23883282E-002, 3.84167604E-002, 1.53642754E-001
91, 5.36895969E-002, 4.19213046E-002, 1.67668025E-001
92, 5.46997069E-002, 4.54316104E-002, 1.81715808E-001
93, 5.54081311E-002, 4.89463843E-002, 1.95780909E-001
94, 5.58117911E-002, 5.24641227E-002, 2.09857306E-001
95, 5.59116825E-002, 5.59832724E-002, 2.23938787E-001
96, 5.57100845E-002, 5.95022992E-002, 2.38019216E-001
97, 5.52109178E-002, 6.30197154E-002, 2.52092650E-001
98, 5.44196813E-002, 6.65341103E-002, 2.66153453E-001
99, 5.33437057E-002, 7.00441783E-002, 2.80196415E-001
100, 5.20123563E-002, 7.35492300E-002, 2.94218834E-001
101, 5.04674286E-002, 7.70492269E-002, 3.08220631E-001
102, 4.87458646E-002, 8.05444599E-002, 3.22203040E-001
103, 4.68839436E-002, 8.40355266E-002, 3.36168518E-001
104, 4.49173401E-002, 8.75232681E-002, 3.50120498E-001
105, 4.28812382E-002, 9.10086979E-002, 3.64063100E-001
106, 1.77387133E-002, 9.10366627E-002, 3.64128985E-001
107, 2.01908829E-002, 8.75675020E-002, 3.50252880E-001
108, 2.25746353E-002, 8.40955711E-002, 3.36365563E-001
109, 2.48558818E-002, 8.06196428E-002, 3.22462062E-001
110, 2.69997624E-002, 7.71386424E-002, 3.08538013E-001
111, 2.89703340E-002, 7.36517091E-002, 2.94589904E-001
112, 3.07302898E-002, 7.01582599E-002, 2.80615334E-001
113, 3.22391132E-002, 6.66580341E-002, 2.66613184E-001
114, 3.34657067E-002, 6.31514577E-002, 2.52585101E-001
115, 3.44014633E-002, 5.96397418E-002, 2.38535915E-001
116, 3.50404451E-002, 5.61242472E-002, 2.24471059E-001
117, 3.53784094E-002, 5.26064268E-002, 2.10396340E-001
118, 3.54128750E-002, 4.90877947E-002, 1.96317810E-001
119, 3.51431408E-002, 4.55698931E-002, 1.82241638E-001
120, 3.45695851E-002, 4.20542661E-002, 1.68174004E-001
121, 3.36933755E-002, 3.85424449E-002, 1.54121036E-001
122, 3.25345756E-002, 3.50355440E-002, 1.40087230E-001
123, 3.11170162E-002, 3.15343362E-002, 1.26075724E-001
124, 2.94778588E-002, 2.80389069E-002, 1.12086926E-001
125, 2.76549540E-002, 2.45489023E-002, 9.81194924E-002
126, 2.56820355E-002, 2.10637531E-002, 8.41712074E-002
127, 2.35911301E-002, 1.75826970E-002, 7.02390806E-002
128, 2.14129060E-002, 1.41048230E-002, 5.63195234E-002
129, 1.91770255E-002, 1.06291229E-002, 4.24085576E-002
130, 1.01455554E-001, 9.44921057E-002, 3.78003038E-001
131, 8.62943239E-002, 9.44930851E-002, 3.78002317E-001
132, 7.11330935E-002, 9.44940644E-002, 3.78001595E-001
133, 5.59718631E-002, 9.44950438E-002, 3.78000874E-001
134, 4.30345303E-002, 7.15048705E-003, 2.85019739E-002
135, 5.41130491E-002, 7.15057639E-003, 2.85017867E-002
136, 6.51915678E-002, 7.15066572E-003, 2.85015995E-002
137, 7.62700866E-002, 7.15075506E-003, 2.85014123E-002
138, 8.91264346E-002, -9.97830400E-003, 4.23019815E-002
139, 9.18432897E-002, -9.98062543E-003, 5.61096896E-002
140, 9.45057943E-002, -9.98212392E-003, 6.99279731E-002
141, 9.70828430E-002, -9.98238221E-003, 8.37624239E-002
142, 9.95478542E-002, -9.98422675E-003, 9.76172858E-002
143, 1.01891110E-001, -9.98783019E-003, 1.11493240E-001
144, 1.04066721E-001, -9.99211144E-003, 1.25396414E-001
145, 1.06039641E-001, -9.99514657E-003, 1.39329736E-001
146, 1.07797960E-001, -9.99698991E-003, 1.53291712E-001
147, 1.09330323E-001, -9.99805648E-003, 1.67280271E-001
148, 1.10625386E-001, -9.99888795E-003, 1.81292889E-001
149, 1.11691570E-001, -9.99936958E-003, 1.95324776E-001
150, 1.12525032E-001, -9.99954352E-003, 2.09372375E-001
151, 1.13124862E-001, -9.99944578E-003, 2.23431888E-001
152, 1.13490526E-001, -9.99911103E-003, 2.37499437E-001
153, 1.13621404E-001, -9.99857388E-003, 2.51571129E-001
154, 1.13516783E-001, -9.99786893E-003, 2.65643040E-001
155, 1.13182598E-001, -9.99755499E-003, 2.79711396E-001
156, 1.12647688E-001, -9.99919519E-003, 2.93773585E-001
157, 1.11940918E-001, -1.00036943E-002, 3.07828214E-001
158, 1.11091611E-001, -1.00056154E-002, 3.21874969E-001
159, 1.10128919E-001, -1.00004857E-002, 3.35914443E-001
160, 1.09080952E-001, -9.99320695E-003, 3.49947815E-001
161, 1.07975749E-001, -9.98882437E-003, 3.63976807E-001
162, 1.08797068E-001, 1.09112103E-002, 3.78003581E-001
163, 1.10751997E-001, 3.18061893E-002, 3.78003626E-001
164, 1.12706926E-001, 5.27011683E-002, 3.78003670E-001
165, 1.14661855E-001, 7.35961473E-002, 3.78003715E-001
166, 4.41063078E-002, 7.36117474E-002, 3.78000848E-001
167, 4.74019828E-002, 5.27274716E-002, 3.78001543E-001
168, 5.06976577E-002, 3.18431958E-002, 3.78002238E-001
169, 5.39933327E-002, 1.09589200E-002, 3.78002933E-001
170, 5.84985187E-002, -9.92607423E-003, 3.63971041E-001
171, 5.96794891E-002, -9.92772535E-003, 3.49936062E-001
172, 6.08015172E-002, -9.92888886E-003, 3.35896277E-001
173, 6.18290987E-002, -9.93000997E-003, 3.21849250E-001
174, 6.27350055E-002, -9.93149422E-003, 3.07793890E-001
175, 6.34888284E-002, -9.93248538E-003, 2.93729589E-001
176, 6.40579596E-002, -9.93374090E-003, 2.79656627E-001
177, 6.44146518E-002, -9.93467375E-003, 2.65576714E-001
178, 6.45276698E-002, -9.93559043E-003, 2.51492780E-001
179, 6.43872948E-002, -9.93615910E-003, 2.37409092E-001
180, 6.39933133E-002, -9.93661820E-003, 2.23330196E-001
181, 6.33503462E-002, -9.93658118E-003, 2.09260488E-001
182, 6.24570920E-002, -9.93638847E-003, 1.95204450E-001
183, 6.13189244E-002, -9.93570448E-003, 1.81166118E-001
184, 5.99317008E-002, -9.93465159E-003, 1.67150181E-001
185, 5.82983047E-002, -9.93456480E-003, 1.53160812E-001
186, 5.64247808E-002, -9.93342285E-003, 1.39201546E-001
187, 5.43227524E-002, -9.92448288E-003, 1.25274854E-001
188, 5.20142318E-002, -9.91595247E-003, 1.11380854E-001
189, 4.95322654E-002, -9.91182301E-003, 9.75167563E-002
190, 4.69058708E-002, -9.91118222E-003, 8.36792628E-002
191, 4.41636636E-002, -9.91011494E-003, 6.98642352E-002
192, 4.13347319E-002, -9.90754627E-003, 5.60666870E-002
193, 3.84484242E-002, -9.90533825E-003, 4.22810178E-002
194, 6.71996340E-002, -9.93703837E-003, 3.78003610E-001
195, 7.71102603E-002, -9.94872097E-003, 3.78003592E-001
196, 8.70208865E-002, -9.96040357E-003, 3.78003573E-001
197, 9.69315128E-002, -9.97208616E-003, 3.78003555E-001
198, 3.18632835E-002, -4.98141484E-003, 2.85012101E-002
199, 2.86936860E-002, 1.40115021E-003, 2.85013470E-002
200, 9.00251728E-002, 1.84705166E-003, 2.84996649E-002
201, 9.01732519E-002, -8.29654202E-003, 2.84995818E-002
202, 2.44727267E-002, -8.22045367E-003, 2.85013880E-002
203, 2.28735142E-002, -1.52207526E-003, 2.85014842E-002
204, 3.08675846E-002, -2.04356350E-003, 2.85012604E-002
205, 3.08266757E-002, -8.02543824E-003, 2.85012149E-002
206, 9.60156266E-002, 1.65143643E-003, 2.84994988E-002
207, 9.47846752E-002, -4.45805565E-003, 2.84994850E-002
208, 9.01864555E-002, -2.66171546E-003, 2.84996253E-002
209, 9.50856305E-002, -9.17804553E-003, 2.84994399E-002
210, 2.78303010E-002, -4.19311883E-003, 2.85013271E-002
211, 1.02692256E-001, 9.09839584E-002, 3.63956600E-001
212, 8.77165539E-002, 9.09907880E-002, 3.63981702E-001
213, 7.27613098E-002, 9.09978881E-002, 3.64007890E-001
214, 5.78208118E-002, 9.10052290E-002, 3.64035043E-001
215, 1.03882009E-001, 8.74724275E-002, 3.49906076E-001
216, 8.90830019E-002, 8.74853555E-002, 3.49955606E-001
217, 7.43293138E-002, 8.74989179E-002, 3.50007681E-001
218, 5.96125846E-002, 8.75131462E-002, 3.50062426E-001
219, 1.05000341E-001, 8.39594865E-002, 3.35849899E-001
220, 9.03708602E-002, 8.39781685E-002, 3.35922477E-001
221, 7.58158435E-002, 8.39978965E-002, 3.35999253E-001
222, 6.13251264E-002, 8.40187923E-002, 3.36080710E-001
223, 1.06014301E-001, 8.04447736E-002, 3.21786617E-001
224, 9.15520790E-002, 8.04689056E-002, 3.21881027E-001
225, 7.71939549E-002, 8.04944139E-002, 3.21980960E-001
226, 6.29296827E-002, 8.05215438E-002, 3.22087396E-001
227, 1.06894202E-001, 7.69280987E-002, 3.07715464E-001
228, 9.25971033E-002, 7.69573348E-002, 3.07830322E-001
229, 7.84338109E-002, 7.69881299E-002, 3.07951438E-001
230, 6.43944961E-002, 7.70208601E-002, 3.08080315E-001
231, 1.07609847E-001, 7.34094501E-002, 2.93636389E-001
232, 9.34755662E-002, 7.34433867E-002, 2.93770079E-001
233, 7.95043144E-002, 7.34788670E-002, 2.93909971E-001
234, 6.56864407E-002, 7.35163861E-002, 2.94058043E-001
235, 1.08127685E-001, 6.98890158E-002, 2.79550140E-001
236, 9.41567569E-002, 6.99272105E-002, 2.79700893E-001
237, 8.03744172E-002, 6.99666804E-002, 2.79856776E-001
238, 6.67720573E-002, 7.00080280E-002, 2.80020199E-001
239, 1.08419954E-001, 6.63673074E-002, 2.65458759E-001
240, 9.46130459E-002, 6.64092372E-002, 2.65624482E-001
241, 8.10154285E-002, 6.64519173E-002, 2.65793237E-001
242, 6.76189470E-002, 6.64960180E-002, 2.65967707E-001
243, 1.08463821E-001, 6.28451298E-002, 2.51365464E-001
244, 9.48214719E-002, 6.28901880E-002, 2.51543729E-001
245, 8.14040586E-002, 6.29352513E-002, 2.51722047E-001
246, 6.82022682E-002, 6.29810159E-002, 2.51903204E-001
247, 1.08237637E-001, 5.93235489E-002, 2.37274516E-001
248, 9.47641261E-002, 5.93710373E-002, 2.37462530E-001
249, 8.15238874E-002, 5.94176450E-002, 2.37647054E-001
250, 6.85078580E-002, 5.94640668E-002, 2.37830868E-001
251, 1.07733822E-001, 5.58037660E-002, 2.23190722E-001
252, 9.44310666E-002, 5.58529230E-002, 2.23385437E-001
253, 8.13647930E-002, 5.59002466E-002, 2.23572852E-001
254, 6.85269614E-002, 5.59464058E-002, 2.23755642E-001
255, 1.06951541E-001, 5.22870056E-002, 2.09118980E-001
256, 9.38181673E-002, 5.23370607E-002, 2.09317314E-001
257, 8.09215034E-002, 5.23843062E-002, 2.09504442E-001
258, 6.82545220E-002, 5.24293726E-002, 2.09682884E-001
259, 1.05893789E-001, 4.87744676E-002, 1.95064092E-001
260, 9.29246276E-002, 4.88246949E-002, 1.95263140E-001
261, 8.01921278E-002, 4.88711165E-002, 1.95446995E-001
262, 6.76883204E-002, 4.89143548E-002, 1.95618147E-001
263, 1.04553795E-001, 4.52675560E-002, 1.81031676E-001
264, 9.17499319E-002, 4.53170906E-002, 1.81227976E-001
265, 7.91773496E-002, 4.53619592E-002, 1.81405641E-001
266, 6.68287522E-002, 4.54027344E-002, 1.81566960E-001
267, 1.02941341E-001, 4.17672682E-002, 1.67025722E-001
268, 9.03003345E-002, 4.18153357E-002, 1.67216176E-001
269, 7.78825089E-002, 4.18579993E-002, 1.67385041E-001
270, 6.56804051E-002, 4.18958060E-002, 1.67534504E-001
271, 1.01065671E-001, 3.82745420E-002, 1.53049986E-001
272, 8.85855848E-002, 3.83203551E-002, 1.53231444E-001
273, 7.63176068E-002, 3.83602171E-002, 1.53389121E-001
274, 6.42533621E-002, 3.83946748E-002, 1.53525204E-001
275, 9.89365049E-002, 3.47901612E-002, 1.39107604E-001
276, 8.66199793E-002, 3.48327974E-002, 1.39276375E-001
277, 7.44978976E-002, 3.48693077E-002, 1.39420663E-001
278, 6.25629816E-002, 3.49001666E-002, 1.39542365E-001
279, 9.65842579E-002, 3.13139461E-002, 1.25197863E-001
280, 8.44270045E-002, 3.13527997E-002, 1.25351522E-001
281, 7.24452333E-002, 3.13855640E-002, 1.25480842E-001
282, 6.06308012E-002, 3.14127206E-002, 1.25587748E-001
283, 9.40326470E-002, 2.78457345E-002, 1.11320117E-001
284, 8.20321511E-002, 2.78802075E-002, 1.11456271E-001
285, 7.01867967E-002, 2.79088690E-002, 1.11569194E-001
286, 5.84875464E-002, 2.79322194E-002, 1.11660888E-001
287, 9.13077392E-002, 2.43850130E-002, 9.74723152E-002
288, 7.94642024E-002, 2.44144878E-002, 9.75884931E-002
289, 6.77531474E-002, 2.44387180E-002, 9.76837052E-002
290, 5.61663975E-002, 2.44581501E-002, 9.77597374E-002
291, 8.84461516E-002, 2.09305328E-002, 8.36494660E-002
292, 7.67561085E-002, 2.09546805E-002, 8.37443515E-002
293, 6.51766832E-002, 2.09742743E-002, 8.38210315E-002
294, 5.37001808E-002, 2.09897238E-002, 8.38811444E-002
295, 8.54794354E-002, 1.74810658E-002, 6.98466610E-002
296, 7.39400394E-002, 1.74996576E-002, 6.99193378E-002
297, 6.24897808E-002, 1.75144878E-002, 6.99769765E-002
298, 5.11210553E-002, 1.75259463E-002, 7.00211363E-002
299, 8.24392889E-002, 1.40352412E-002, 5.60584192E-002
300, 7.10485780E-002, 1.40481276E-002, 5.61082891E-002
301, 5.97254184E-002, 1.40581200E-002, 5.61465893E-002
302, 4.84610826E-002, 1.40656486E-002, 5.61750396E-002
303, 7.93525395E-002, 1.05918803E-002, 4.22800285E-002
304, 6.81165117E-002, 1.05986186E-002, 4.23053211E-002
305, 5.69191524E-002, 1.06037106E-002, 4.23240319E-002
306, 4.57534815E-002, 1.06074837E-002, 4.23374704E-002
307, 9.03434656E-002, 6.49967884E-003, 4.22607014E-002
308, 9.35056687E-002, 9.27148109E-003, 5.60266254E-002
309, 9.66156074E-002, 1.20439815E-002, 6.98037054E-002
310, 9.96467354E-002, 1.48185384E-002, 8.35981015E-002
311, 1.02571320E-001, 1.75954973E-002, 9.74140845E-002
312, 1.05360673E-001, 2.03752415E-002, 1.11255805E-001
313, 1.07984825E-001, 2.31580176E-002, 1.25126835E-001
314, 1.10412745E-001, 2.59445226E-002, 1.39032828E-001
315, 1.12610788E-001, 2.87342695E-002, 1.52973436E-001
316, 1.14552422E-001, 3.15259876E-002, 1.66943127E-001
317, 1.16231689E-001, 3.43207956E-002, 1.80945340E-001
318, 1.17644739E-001, 3.71179480E-002, 1.94973256E-001
319, 1.18789328E-001, 3.99176289E-002, 2.09024555E-001
320, 1.19663898E-001, 4.27190001E-002, 2.23091678E-001
321, 1.20268653E-001, 4.55234248E-002, 2.37178018E-001
322, 1.20604097E-001, 4.83286719E-002, 2.51268904E-001
323, 1.20672600E-001, 5.11355076E-002, 2.65364867E-001
324, 1.20484151E-001, 5.39439533E-002, 2.79464053E-001
325, 1.20068854E-001, 5.67524569E-002, 2.93559440E-001
326, 1.19460156E-001, 5.95606567E-002, 3.07649524E-001
327, 1.18691267E-001, 6.23683084E-002, 3.21731691E-001
328, 1.17794576E-001, 6.51766340E-002, 3.35811193E-001
329, 1.16803149E-001, 6.79830599E-002, 3.49876990E-001
330, 1.15747744E-001, 7.07907834E-002, 3.63947411E-001
331, 9.00428547E-002, 2.39880398E-003, 4.22737991E-002
332, 9.30972690E-002, 4.49598705E-003, 5.60527026E-002
333, 9.60986721E-002, 6.59291072E-003, 6.98424399E-002
334, 9.90202607E-002, 8.69007049E-003, 8.36491378E-002
335, 1.01834250E-001, 1.07871934E-002, 9.74771850E-002
336, 1.04511960E-001, 1.28840935E-002, 1.11329965E-001
337, 1.07023941E-001, 1.49806051E-002, 1.25211413E-001
338, 1.09339643E-001, 1.70766295E-002, 1.39125181E-001
339, 1.11426973E-001, 1.91715285E-002, 1.53070801E-001
340, 1.13263703E-001, 2.12646651E-002, 1.67045202E-001
341, 1.14845504E-001, 2.33568826E-002, 1.81049453E-001
342, 1.16169237E-001, 2.54477927E-002, 1.95073986E-001
343, 1.17233647E-001, 2.75386529E-002, 2.09120188E-001
344, 1.18037538E-001, 2.96297965E-002, 2.23183099E-001
345, 1.18580647E-001, 3.17220399E-002, 2.37260820E-001
346, 1.18863256E-001, 3.38151786E-002, 2.51344597E-001
347, 1.18886740E-001, 3.59099729E-002, 2.65432578E-001
348, 1.18660928E-001, 3.80066227E-002, 2.79522500E-001
349, 1.18215130E-001, 4.01040076E-002, 2.93609091E-001
350, 1.17581547E-001, 4.22017061E-002, 3.07690149E-001
351, 1.16792245E-001, 4.43002165E-002, 3.21764223E-001
352, 1.15878823E-001, 4.64003072E-002, 3.35833182E-001
353, 1.14872885E-001, 4.85005977E-002, 3.49893240E-001
354, 1.13805002E-001, 5.06012373E-002, 3.63952238E-001
355, 8.97397190E-002, -1.71452218E-003, 4.22845409E-002
356, 9.26838777E-002, -3.04548533E-004, 5.60742062E-002
357, 9.55743363E-002, 1.10471698E-003, 6.98741059E-002
358, 9.83842670E-002, 2.51336225E-003, 8.36910691E-002
359, 1.01085829E-001, 3.92050790E-003, 9.75293566E-002
360, 1.03650379E-001, 5.32579903E-003, 1.11391175E-001
361, 1.06049114E-001, 6.72887857E-003, 1.25281015E-001
362, 1.08252246E-001, 8.12947348E-003, 1.39201482E-001
363, 1.10229452E-001, 9.52724762E-003, 1.53152486E-001
364, 1.11962589E-001, 1.09219505E-002, 1.67132626E-001
365, 1.13448777E-001, 1.23141679E-002, 1.81142472E-001
366, 1.14684920E-001, 1.37033336E-002, 1.95164469E-001
367, 1.15671000E-001, 1.50914842E-002, 2.09208407E-001
368, 1.16405813E-001, 1.64791808E-002, 2.23269045E-001
369, 1.16888717E-001, 1.78670862E-002, 2.37341818E-001
370, 1.17119555E-001, 1.92556975E-002, 2.51420550E-001
371, 1.17098803E-001, 2.06457343E-002, 2.65502239E-001
372, 1.16836207E-001, 2.20372693E-002, 2.79584088E-001
373, 1.16360303E-001, 2.34293462E-002, 2.93662109E-001
374, 1.15702090E-001, 2.48216447E-002, 3.07734189E-001
375, 1.14892601E-001, 2.62155733E-002, 3.21799369E-001
376, 1.13962565E-001, 2.76123340E-002, 3.35858417E-001
377, 1.12942397E-001, 2.90103783E-002, 3.49910454E-001
378, 1.11862016E-001, 3.04083227E-002, 3.63959322E-001
379, 8.94342245E-002, -5.84023390E-003, 4.22936987E-002
380, 9.22658189E-002, -5.13001053E-003, 5.60926689E-002
381, 9.50430483E-002, -4.42025447E-003, 6.99007458E-002
382, 9.77393703E-002, -3.71095703E-003, 8.37266859E-002
383, 1.00326866E-001, -3.00370619E-003, 9.75743785E-002
384, 1.02776858E-001, -2.29839031E-003, 1.11443748E-001
385, 1.05061458E-001, -1.59541175E-003, 1.25340961E-001
386, 1.07151757E-001, -8.94757291E-004, 1.39267716E-001
387, 1.09019367E-001, -1.96045923E-004, 1.53224250E-001
388, 1.10650077E-001, 5.00604692E-004, 1.67210630E-001
389, 1.12042428E-001, 1.19517564E-003, 1.81230587E-001
390, 1.13192335E-001, 1.88699424E-003, 1.95247687E-001
391, 1.14101761E-001, 2.57816744E-003, 2.09291400E-001
392, 1.14768983E-001, 3.26888800E-003, 2.23351395E-001
393, 1.15192974E-001, 3.95959466E-003, 2.37421256E-001
394, 1.15373049E-001, 4.65080158E-003, 2.51496249E-001
395, 1.15308833E-001, 5.34298095E-003, 2.65572748E-001
396, 1.15010038E-001, 6.03580684E-003, 2.79647456E-001
397, 1.14504426E-001, 6.72825088E-003, 2.93717307E-001
398, 1.13821824E-001, 7.41997185E-003, 3.07780536E-001
399, 1.12992340E-001, 8.11382628E-003, 3.21836517E-001
400, 1.12045864E-001, 8.81217404E-003, 3.35885774E-001
401, 1.11011685E-001, 9.51240999E-003, 3.49928719E-001
402, 1.09918858E-001, 1.02117016E-002, 3.63967701E-001
403, 4.60034874E-002, 7.08322181E-002, 3.64041818E-001
404, 4.78669088E-002, 6.80518786E-002, 3.50078642E-001
405, 4.96624641E-002, 6.52700733E-002, 3.36107271E-001
406, 5.13558667E-002, 6.24862075E-002, 3.22124118E-001
407, 5.29124406E-002, 5.96997759E-002, 3.08126275E-001
408, 5.42970296E-002, 5.69104926E-002, 2.94111767E-001
409, 5.54739754E-002, 5.41182792E-002, 2.80079764E-001
410, 5.64071636E-002, 5.13232711E-002, 2.66030432E-001
411, 5.70638625E-002, 4.85263279E-002, 2.51968029E-001
412, 5.74331394E-002, 4.57278922E-002, 2.37897613E-001
413, 5.75126819E-002, 4.29280576E-002, 2.23823620E-001
414, 5.73013453E-002, 4.01269951E-002, 2.09750869E-001
415, 5.67991462E-002, 3.73248171E-002, 1.95683818E-001
416, 5.60074985E-002, 3.45224414E-002, 1.81630838E-001
417, 5.49286675E-002, 3.17195060E-002, 1.67593649E-001
418, 5.35664171E-002, 2.89169219E-002, 1.53580051E-001
419, 5.19274103E-002, 2.61140968E-002, 1.39588952E-001
420, 5.00400011E-002, 2.33129285E-002, 1.25628179E-001
421, 4.79394240E-002, 2.05126457E-002, 1.11692724E-001
422, 4.56601972E-002, 1.77138466E-002, 9.77839373E-002
423, 4.32345897E-002, 1.49164920E-002, 8.38981818E-002
424, 4.06935251E-002, 1.21206276E-002, 7.00315840E-002
425, 3.80668516E-002, 9.32602189E-003, 5.61798361E-002
426, 3.53836032E-002, 6.53223115E-003, 4.23382556E-002
427, 4.91261935E-002, 5.06482939E-002, 3.64022731E-001
428, 5.08177411E-002, 4.85685676E-002, 3.50040293E-001
429, 5.24431118E-002, 4.64880095E-002, 3.36050650E-001
430, 5.39689282E-002, 4.44063567E-002, 3.22050698E-001
431, 5.53615204E-002, 4.23233253E-002, 3.08038000E-001
432, 5.65868421E-002, 4.02388663E-002, 2.94011021E-001
433, 5.76104878E-002, 3.81530332E-002, 2.79969358E-001
434, 5.83977258E-002, 3.60661335E-002, 2.65914035E-001
435, 5.89168174E-002, 3.39787606E-002, 2.51848802E-001
436, 5.91572526E-002, 3.18907565E-002, 2.37777919E-001
437, 5.91178828E-002, 2.98016075E-002, 2.23705706E-001
438, 5.87983807E-002, 2.77108502E-002, 2.09636832E-001
439, 5.81992203E-002, 2.56180432E-002, 1.95576033E-001
440, 5.73217865E-002, 2.35230080E-002, 1.81529627E-001
441, 5.61680986E-002, 2.14251930E-002, 1.67500994E-001
442, 5.47409793E-002, 1.93242851E-002, 1.53494814E-001
443, 5.30453576E-002, 1.72200659E-002, 1.39512781E-001
444, 5.11049710E-002, 1.51138244E-002, 1.25559633E-001
445, 4.89536252E-002, 1.30051548E-002, 1.11632903E-001
446, 4.66246488E-002, 1.08943013E-002, 9.77329280E-002
447, 4.41496711E-002, 8.78188576E-003, 8.38565606E-002
448, 4.15591711E-002, 6.66877257E-003, 6.99998570E-002
449, 3.88828171E-002, 4.55530529E-003, 5.61584042E-002
450, 3.61496839E-002, 2.44129592E-003, 4.23273758E-002
451, 5.22497297E-002, 3.04606714E-002, 3.64004728E-001
452, 5.37702637E-002, 2.90777062E-002, 3.50004048E-001
453, 5.52263507E-002, 2.76943552E-002, 3.35997029E-001
454, 5.65855341E-002, 2.63106024E-002, 3.21980981E-001
455, 5.78151624E-002, 2.49262301E-002, 3.07953880E-001
456, 5.88822847E-002, 2.35413707E-002, 2.93914559E-001
457, 5.97537277E-002, 2.21560864E-002, 2.79862955E-001
458, 6.03961212E-002, 2.07706769E-002, 2.65800423E-001
459, 6.07786641E-002, 1.93855173E-002, 2.51730164E-001
460, 6.08910573E-002, 1.80002958E-002, 2.37656275E-001
461, 6.07331980E-002, 1.66143213E-002, 2.23583166E-001
462, 6.03055157E-002, 1.52269149E-002, 2.09515426E-001
463, 5.96089075E-002, 1.38374131E-002, 1.95457756E-001
464, 5.86447897E-002, 1.24452301E-002, 1.81415538E-001
465, 5.74149519E-002, 1.10497338E-002, 1.67392798E-001
466, 5.59214675E-002, 9.65005363E-003, 1.53392376E-001
467, 5.41678946E-002, 8.24643971E-003, 1.39418587E-001
468, 5.21736602E-002, 6.84034063E-003, 1.25474882E-001
469, 4.99706582E-002, 5.43043386E-003, 1.11557959E-001
470, 4.75912980E-002, 4.01628226E-003, 9.76688497E-002
471, 4.50664345E-002, 2.59880039E-003, 8.38041862E-002
472, 4.24260333E-002, 1.17960283E-003, 6.99598722E-002
473, 3.96995503E-002, -2.40610622E-004, 5.61313662E-002
474, 3.69161109E-002, -1.66222393E-003, 4.23136533E-002
475, 5.53741398E-002, 1.02692632E-002, 3.63987591E-001
476, 5.67245711E-002, 9.57905740E-003, 3.49969474E-001
477, 5.80123120E-002, 8.88877171E-003, 3.35945760E-001
478, 5.92058330E-002, 8.19857839E-003, 3.21914115E-001
479, 6.02735205E-002, 7.50810355E-003, 3.07872867E-001
480, 6.11834921E-002, 6.81768830E-003, 2.93821152E-001
481, 6.19037897E-002, 6.12725467E-003, 2.79759160E-001
482, 6.24023590E-002, 5.43702908E-003, 2.65688381E-001
483, 6.26493049E-002, 4.74721203E-003, 2.51611668E-001
484, 6.26343927E-002, 4.05764577E-003, 2.37533203E-001
485, 6.23584628E-002, 3.36782329E-003, 2.23457535E-001
486, 6.18226441E-002, 2.67723613E-003, 2.09389194E-001
487, 6.10282253E-002, 1.98537382E-003, 1.95332738E-001
488, 5.99766918E-002, 1.29171199E-003, 1.81293112E-001
489, 5.86696698E-002, 5.95920626E-004, 1.67275042E-001
490, 5.71085031E-002, -1.03205972E-004, 1.53278832E-001
491, 5.52957907E-002, -8.04731564E-004, 1.39312464E-001
492, 5.32468540E-002, -1.50590306E-003, 1.25379388E-001
493, 5.09912075E-002, -2.21007467E-003, 1.11472382E-001
494, 4.85607558E-002, -2.91915670E-003, 9.75954088E-002
495, 4.59854143E-002, -3.63215363E-003, 8.37440072E-002
496, 4.32945360E-002, -4.34654820E-003, 6.99138223E-002
497, 4.05173246E-002, -5.06143122E-003, 5.61001811E-002
498, 3.76829624E-002, -5.77786050E-003, 4.22978216E-002
499, 4.52000395E-002, -6.50601461E-003, 2.85008504E-002
500, 5.55451473E-002, -6.51668406E-003, 2.85005664E-002
501, 6.58854079E-002, -6.52766535E-003, 2.85002825E-002
502, 7.62262511E-002, -6.53880332E-003, 2.84999986E-002
503, 4.46788099E-002, -3.09175782E-003, 2.85009320E-002
504, 5.52041494E-002, -3.09965109E-003, 2.85006431E-002
505, 6.57209896E-002, -3.10795588E-003, 2.85003544E-002
506, 7.62386163E-002, -3.11638442E-003, 2.85000656E-002
507, 4.41442572E-002, 3.22474430E-004, 2.85010139E-002
508, 5.48520923E-002, 3.17245621E-004, 2.85007200E-002
509, 6.55506925E-002, 3.11678046E-004, 2.85004264E-002
510, 7.62499608E-002, 3.06091758E-004, 2.85001328E-002
511, 4.35965841E-002, 3.73658812E-003, 2.85010962E-002
512, 5.44886349E-002, 3.73399534E-003, 2.85007973E-002
513, 6.53742934E-002, 3.73122184E-003, 2.85004986E-002
514, 7.62603061E-002, 3.72850871E-003, 2.85001999E-002
515, 6.83685259E-002, -9.93382211E-003, 3.63969987E-001
516, 7.82498257E-002, -9.94701649E-003, 3.63969985E-001
517, 8.81440770E-002, -9.96022812E-003, 3.63971067E-001
518, 9.80523799E-002, -9.97345845E-003, 3.63973295E-001
519, 6.95060937E-002, -9.93604075E-003, 3.49934128E-001
520, 7.93579891E-002, -9.94919586E-003, 3.49934325E-001
521, 8.92369013E-002, -9.96238694E-003, 3.49936624E-001
522, 9.91441516E-002, -9.97561576E-003, 3.49941071E-001
523, 7.05835906E-002, -9.93817939E-003, 3.35893868E-001
524, 8.04063032E-002, -9.95129551E-003, 3.35894561E-001
525, 9.02706949E-002, -9.96446714E-003, 3.35898202E-001
526, 1.00177865E-001, -9.97769574E-003, 3.35904783E-001
527, 7.15697063E-002, -9.94019634E-003, 3.21847285E-001
528, 8.13650894E-002, -9.95327591E-003, 3.21848992E-001
529, 9.12164502E-002, -9.96643006E-003, 3.21854169E-001
530, 1.01124919E-001, -9.97966030E-003, 3.21862781E-001
531, 7.24356196E-002, -9.94205314E-003, 3.07793277E-001
532, 8.22053909E-002, -9.95509844E-003, 3.07796563E-001
533, 9.20454045E-002, -9.96823736E-003, 3.07803483E-001
534, 1.01956807E-001, -9.98147141E-003, 3.07813980E-001
535, 7.31517301E-002, -9.94371031E-003, 2.93731424E-001
536, 8.28982112E-002, -9.95672440E-003, 2.93736935E-001
537, 9.27288615E-002, -9.96985071E-003, 2.93745805E-001
538, 1.02644791E-001, -9.98309073E-003, 2.93757964E-001
539, 7.36882981E-002, -9.94512811E-003, 2.79662197E-001
540, 8.34151847E-002, -9.95811589E-003, 2.79670641E-001
541, 9.32388694E-002, -9.97123279E-003, 2.79681655E-001
542, 1.03160548E-001, -9.98448042E-003, 2.79695179E-001
543, 7.40185280E-002, -9.94627067E-003, 2.65587219E-001
544, 8.37305347E-002, -9.95923840E-003, 2.65599242E-001
545, 9.35497802E-002, -9.97234926E-003, 2.65612543E-001
546, 1.03477394E-001, -9.98560477E-003, 2.65627088E-001
547, 7.41183603E-002, -9.94710574E-003, 2.51509209E-001
548, 8.38228777E-002, -9.96006326E-003, 2.51525303E-001
549, 9.36406081E-002, -9.97317199E-003, 2.51540966E-001
550, 1.03572550E-001, -9.98643323E-003, 2.51556203E-001
551, 7.39758794E-002, -9.94761721E-003, 2.37431860E-001
552, 8.36798970E-002, -9.96057386E-003, 2.37452232E-001
553, 9.34995103E-002, -9.97368498E-003, 2.37470237E-001
554, 1.03435750E-001, -9.98695194E-003, 2.37485938E-001
555, 7.35874312E-002, -9.94780001E-003, 2.23359287E-001
556, 8.32964907E-002, -9.96076318E-003, 2.23383886E-001
557, 9.31215128E-002, -9.97388141E-003, 2.23404107E-001
558, 1.03063759E-001, -9.98715638E-003, 2.23420067E-001
559, 7.29536402E-002, -9.94765476E-003, 2.09295683E-001
560, 8.26715699E-002, -9.96062957E-003, 2.09324286E-001
561, 9.25051850E-002, -9.97375918E-003, 2.09346494E-001
562, 1.02455811E-001, -9.98704534E-003, 2.09362474E-001
563, 7.20745615E-002, -9.94718132E-003, 1.95245270E-001
564, 8.18052291E-002, -9.96017296E-003, 1.95277491E-001
565, 9.16505889E-002, -9.97331817E-003, 1.95301350E-001
566, 1.01612148E-001, -9.98661894E-003, 1.95317054E-001
567, 7.09525818E-002, -9.94638268E-003, 1.81212107E-001
568, 8.06989273E-002, -9.95939510E-003, 1.81247474E-001
569, 9.05588698E-002, -9.97255971E-003, 1.81272570E-001
570, 1.00533831E-001, -9.98587841E-003, 1.81287643E-001
571, 6.95877717E-002, -9.94525872E-003, 1.67200358E-001
572, 7.93541202E-002, -9.95829773E-003, 1.67238141E-001
573, 8.92317720E-002, -9.97148596E-003, 1.67263945E-001
574, 9.92227515E-002, -9.98482610E-003, 1.67277987E-001
575, 6.79835557E-002, -9.94381383E-003, 1.53213790E-001
576, 7.77744878E-002, -9.95688559E-003, 1.53253032E-001
577, 8.76721726E-002, -9.97010056E-003, 1.53279014E-001
578, 9.76788616E-002, -9.98346173E-003, 1.53291928E-001
579, 6.61473798E-002, -9.94205780E-003, 1.39255433E-001
580, 7.59681043E-002, -9.95516933E-003, 1.39294903E-001
581, 8.58883378E-002, -9.96841444E-003, 1.39320430E-001
582, 9.59108287E-002, -9.98179677E-003, 1.39332118E-001
583, 6.40921422E-002, -9.94000776E-003, 1.25327176E-001
584, 7.39482287E-002, -9.95316658E-003, 1.25365381E-001
585, 8.38933181E-002, -9.96644492E-003, 1.25389788E-001
586, 9.39309886E-002, -9.97984758E-003, 1.25400318E-001
587, 6.18384256E-002, -9.93769119E-003, 1.11429078E-001
588, 7.17346294E-002, -9.95090371E-003, 1.11464498E-001
589, 8.17062167E-002, -9.96421753E-003, 1.11487180E-001
590, 9.17568354E-002, -9.97763752E-003, 1.11496942E-001
591, 5.94141163E-002, -9.93514543E-003, 9.75591242E-002
592, 6.93533988E-002, -9.94841568E-003, 9.75904849E-002
593, 7.93535878E-002, -9.96176780E-003, 9.76107553E-002
594, 8.94177111E-002, -9.97520586E-003, 9.76197557E-002
595, 5.68474500E-002, -9.93240833E-003, 8.37142743E-002
596, 6.68321930E-002, -9.94573954E-003, 8.37404411E-002
597, 7.68639374E-002, -9.95913396E-003, 8.37574742E-002
598, 8.69462910E-002, -9.97259644E-003, 8.37649831E-002
599, 5.41661167E-002, -9.92951705E-003, 6.98907188E-002
600, 6.41975884E-002, -9.94291096E-003, 6.99108427E-002
601, 7.42621906E-002, -9.95634944E-003, 6.99241299E-002
602, 8.43636689E-002, -9.96983753E-003, 6.99300585E-002
603, 5.13978223E-002, -9.92650882E-003, 5.60839193E-002
604, 6.14763921E-002, -9.93996595E-003, 5.60974249E-002
605, 7.15746702E-002, -9.95344960E-003, 5.61065893E-002
606, 8.16960092E-002, -9.96696430E-003, 5.61108681E-002
607, 4.85695674E-002, -9.92341994E-003, 4.22889022E-002
608, 5.86946047E-002, -9.93693945E-003, 4.22954988E-002
609, 6.88275718E-002, -9.95046966E-003, 4.23001708E-002
610, 7.89709569E-002, -9.96401389E-003, 4.23024742E-002
**
** Elements ++++++++++++++++++++++++++++++++++++++++++++++++
**
*Element, Type=S3, Elset=Compound-1
1, 15, 200, 2
2, 199, 210, 204
3, 5, 199, 26
4, 28, 205, 202
5, 205, 210, 202
6, 198, 210, 205
7, 201, 208, 18
8, 27, 203, 6
9, 203, 210, 199
10, 200, 208, 206
11, 17, 208, 16
12, 7, 202, 27
13, 1, 206, 33
14, 32, 201, 3
15, 33, 209, 8
16, 202, 203, 27
17, 4, 205, 28
18, 26, 199, 25
19, 25, 204, 24
20, 16, 208, 200
21, 24, 198, 23
22, 16, 200, 15
23, 207, 208, 201
24, 202, 210, 203
25, 206, 208, 207
26, 201, 209, 207
27, 199, 204, 25
28, 24, 204, 198
29, 3, 201, 18
30, 207, 209, 33
31, 198, 205, 23
32, 23, 205, 4
33, 204, 210, 198
34, 206, 207, 33
35, 8, 209, 32
36, 2, 206, 1
37, 200, 206, 2
38, 3, 19, 32
39, 29, 22, 4
40, 29, 4, 28
41, 6, 199, 5
42, 6, 203, 199
43, 28, 202, 7
44, 18, 208, 17
45, 19, 20, 31
46, 32, 19, 31
47, 20, 21, 30
48, 31, 20, 30
49, 21, 22, 29
50, 30, 21, 29
51, 32, 209, 201
52, 9, 34, 10
53, 10, 34, 81
54, 34, 35, 81
55, 81, 35, 80
56, 35, 36, 80
57, 80, 36, 79
58, 36, 37, 79
59, 79, 37, 78
60, 37, 38, 78
61, 78, 38, 77
62, 38, 39, 77
63, 77, 39, 76
64, 39, 40, 76
65, 76, 40, 75
66, 40, 41, 75
67, 75, 41, 74
68, 41, 42, 74
69, 74, 42, 73
70, 42, 43, 73
71, 73, 43, 72
72, 43, 44, 72
73, 72, 44, 71
74, 44, 45, 71
75, 71, 45, 70
76, 45, 46, 70
77, 70, 46, 69
78, 46, 47, 69
79, 69, 47, 68
80, 47, 48, 68
81, 68, 48, 67
82, 48, 49, 67
83, 67, 49, 66
84, 49, 50, 66
85, 66, 50, 65
86, 50, 51, 65
87, 65, 51, 64
88, 51, 52, 64
89, 64, 52, 63
90, 52, 53, 63
91, 63, 53, 62
92, 53, 54, 62
93, 62, 54, 61
94, 54, 55, 61
95, 61, 55, 60
96, 55, 56, 60
97, 60, 56, 59
98, 56, 57, 59
99, 59, 57, 58
100, 57, 2, 58
101, 58, 2, 1
102, 5, 82, 6
103, 6, 82, 129
104, 82, 83, 129
105, 129, 83, 128
106, 83, 84, 128
107, 128, 84, 127
108, 84, 85, 127
109, 127, 85, 126
110, 85, 86, 126
111, 126, 86, 125
112, 86, 87, 125
113, 125, 87, 124
114, 87, 88, 124
115, 124, 88, 123
116, 88, 89, 123
117, 123, 89, 122
118, 89, 90, 122
119, 122, 90, 121
120, 90, 91, 121
121, 121, 91, 120
122, 91, 92, 120
123, 120, 92, 119
124, 92, 93, 119
125, 119, 93, 118
126, 93, 94, 118
127, 118, 94, 117
128, 94, 95, 117
129, 117, 95, 116
130, 95, 96, 116
131, 116, 96, 115
132, 96, 97, 115
133, 115, 97, 114
134, 97, 98, 114
135, 114, 98, 113
136, 98, 99, 113
137, 113, 99, 112
138, 99, 100, 112
139, 112, 100, 111
140, 100, 101, 111
141, 111, 101, 110
142, 101, 102, 110
143, 110, 102, 109
144, 102, 103, 109
145, 109, 103, 108
146, 103, 104, 108
147, 108, 104, 107
148, 104, 105, 107
149, 107, 105, 106
150, 105, 11, 106
151, 106, 11, 12
152, 9, 130, 34
153, 130, 211, 34
154, 130, 131, 211
155, 131, 212, 211
156, 131, 132, 212
157, 132, 213, 212
158, 132, 133, 213
159, 133, 214, 213
160, 133, 11, 214
161, 11, 105, 214
162, 34, 211, 35
163, 211, 215, 35
164, 211, 212, 215
165, 212, 216, 215
166, 212, 213, 216
167, 213, 217, 216
168, 213, 214, 217
169, 214, 218, 217
170, 214, 105, 218
171, 105, 104, 218
172, 35, 215, 36
173, 215, 219, 36
174, 215, 216, 219
175, 216, 220, 219
176, 216, 217, 220
177, 217, 221, 220
178, 217, 218, 221
179, 218, 222, 221
180, 218, 104, 222
181, 104, 103, 222
182, 36, 219, 37
183, 219, 223, 37
184, 219, 220, 223
185, 220, 224, 223
186, 220, 221, 224
187, 221, 225, 224
188, 221, 222, 225
189, 222, 226, 225
190, 222, 103, 226
191, 103, 102, 226
192, 37, 223, 38
193, 223, 227, 38
194, 223, 224, 227
195, 224, 228, 227
196, 224, 225, 228
197, 225, 229, 228
198, 225, 226, 229
199, 226, 230, 229
200, 226, 102, 230
201, 102, 101, 230
202, 38, 227, 39
203, 227, 231, 39
204, 227, 228, 231
205, 228, 232, 231
206, 228, 229, 232
207, 229, 233, 232
208, 229, 230, 233
209, 230, 234, 233
210, 230, 101, 234
211, 101, 100, 234
212, 39, 231, 40
213, 231, 235, 40
214, 231, 232, 235
215, 232, 236, 235
216, 232, 233, 236
217, 233, 237, 236
218, 233, 234, 237
219, 234, 238, 237
220, 234, 100, 238
221, 100, 99, 238
222, 40, 235, 41
223, 235, 239, 41
224, 235, 236, 239
225, 236, 240, 239
226, 236, 237, 240
227, 237, 241, 240
228, 237, 238, 241
229, 238, 242, 241
230, 238, 99, 242
231, 99, 98, 242
232, 41, 239, 42
233, 239, 243, 42
234, 239, 240, 243
235, 240, 244, 243
236, 240, 241, 244
237, 241, 245, 244
238, 241, 242, 245
239, 242, 246, 245
240, 242, 98, 246
241, 98, 97, 246
242, 42, 243, 43
243, 243, 247, 43
244, 243, 244, 247
245, 244, 248, 247
246, 244, 245, 248
247, 245, 249, 248
248, 245, 246, 249
249, 246, 250, 249
250, 246, 97, 250
251, 97, 96, 250
252, 43, 247, 44
253, 247, 251, 44
254, 247, 248, 251
255, 248, 252, 251
256, 248, 249, 252
257, 249, 253, 252
258, 249, 250, 253
259, 250, 254, 253
260, 250, 96, 254
261, 96, 95, 254
262, 44, 251, 45
263, 251, 255, 45
264, 251, 252, 255
265, 252, 256, 255
266, 252, 253, 256
267, 253, 257, 256
268, 253, 254, 257
269, 254, 258, 257
270, 254, 95, 258
271, 95, 94, 258
272, 45, 255, 46
273, 255, 259, 46
274, 255, 256, 259
275, 256, 260, 259
276, 256, 257, 260
277, 257, 261, 260
278, 257, 258, 261
279, 258, 262, 261
280, 258, 94, 262
281, 94, 93, 262
282, 46, 259, 47
283, 259, 263, 47
284, 259, 260, 263
285, 260, 264, 263
286, 260, 261, 264
287, 261, 265, 264
288, 261, 262, 265
289, 262, 266, 265
290, 262, 93, 266
291, 93, 92, 266
292, 47, 263, 48
293, 263, 267, 48
294, 263, 264, 267
295, 264, 268, 267
296, 264, 265, 268
297, 265, 269, 268
298, 265, 266, 269
299, 266, 270, 269
300, 266, 92, 270
301, 92, 91, 270
302, 48, 267, 49
303, 267, 271, 49
304, 267, 268, 271
305, 268, 272, 271
306, 268, 269, 272
307, 269, 273, 272
308, 269, 270, 273
309, 270, 274, 273
310, 270, 91, 274
311, 91, 90, 274
312, 49, 271, 50
313, 271, 275, 50
314, 271, 272, 275
315, 272, 276, 275
316, 272, 273, 276
317, 273, 277, 276
318, 273, 274, 277
319, 274, 278, 277
320, 274, 90, 278
321, 90, 89, 278
322, 50, 275, 51
323, 275, 279, 51
324, 275, 276, 279
325, 276, 280, 279
326, 276, 277, 280
327, 277, 281, 280
328, 277, 278, 281
329, 278, 282, 281
330, 278, 89, 282
331, 89, 88, 282
332, 51, 279, 52
333, 279, 283, 52
334, 279, 280, 283
335, 280, 284, 283
336, 280, 281, 284
337, 281, 285, 284
338, 281, 282, 285
339, 282, 286, 285
340, 282, 88, 286
341, 88, 87, 286
342, 52, 283, 53
343, 283, 287, 53
344, 283, 284, 287
345, 284, 288, 287
346, 284, 285, 288
347, 285, 289, 288
348, 285, 286, 289
349, 286, 290, 289
350, 286, 87, 290
351, 87, 86, 290
352, 53, 287, 54
353, 287, 291, 54
354, 287, 288, 291
355, 288, 292, 291
356, 288, 289, 292
357, 289, 293, 292
358, 289, 290, 293
359, 290, 294, 293
360, 290, 86, 294
361, 86, 85, 294
362, 54, 291, 55
363, 291, 295, 55
364, 291, 292, 295
365, 292, 296, 295
366, 292, 293, 296
367, 293, 297, 296
368, 293, 294, 297
369, 294, 298, 297
370, 294, 85, 298
371, 85, 84, 298
372, 55, 295, 56
373, 295, 299, 56
374, 295, 296, 299
375, 296, 300, 299
376, 296, 297, 300
377, 297, 301, 300
378, 297, 298, 301
379, 298, 302, 301
380, 298, 84, 302
381, 84, 83, 302
382, 56, 299, 57
383, 299, 303, 57
384, 299, 300, 303
385, 300, 304, 303
386, 300, 301, 304
387, 301, 305, 304
388, 301, 302, 305
389, 302, 306, 305
390, 302, 83, 306
391, 83, 82, 306
392, 57, 303, 2
393, 303, 137, 2
394, 303, 304, 137
395, 304, 136, 137
396, 304, 305, 136
397, 305, 135, 136
398, 305, 306, 135
399, 306, 134, 135
400, 306, 82, 134
401, 82, 5, 134
402, 2, 15, 57
403, 57, 15, 307
404, 57, 307, 56
405, 56, 307, 308
406, 56, 308, 55
407, 55, 308, 309
408, 55, 309, 54
409, 54, 309, 310
410, 54, 310, 53
411, 53, 310, 311
412, 53, 311, 52
413, 52, 311, 312
414, 52, 312, 51
415, 51, 312, 313
416, 51, 313, 50
417, 50, 313, 314
418, 50, 314, 49
419, 49, 314, 315
420, 49, 315, 48
421, 48, 315, 316
422, 48, 316, 47
423, 47, 316, 317
424, 47, 317, 46
425, 46, 317, 318
426, 46, 318, 45
427, 45, 318, 319
428, 45, 319, 44
429, 44, 319, 320
430, 44, 320, 43
431, 43, 320, 321
432, 43, 321, 42
433, 42, 321, 322
434, 42, 322, 41
435, 41, 322, 323
436, 41, 323, 40
437, 40, 323, 324
438, 40, 324, 39
439, 39, 324, 325
440, 39, 325, 38
441, 38, 325, 326
442, 38, 326, 37
443, 37, 326, 327
444, 37, 327, 36
445, 36, 327, 328
446, 36, 328, 35
447, 35, 328, 329
448, 35, 329, 34
449, 34, 329, 330
450, 34, 330, 9
451, 9, 330, 165
452, 15, 16, 307
453, 307, 16, 331
454, 307, 331, 308
455, 308, 331, 332
456, 308, 332, 309
457, 309, 332, 333
458, 309, 333, 310
459, 310, 333, 334
460, 310, 334, 311
461, 311, 334, 335
462, 311, 335, 312
463, 312, 335, 336
464, 312, 336, 313
465, 313, 336, 337
466, 313, 337, 314
467, 314, 337, 338
468, 314, 338, 315
469, 315, 338, 339
470, 315, 339, 316
471, 316, 339, 340
472, 316, 340, 317
473, 317, 340, 341
474, 317, 341, 318
475, 318, 341, 342
476, 318, 342, 319
477, 319, 342, 343
478, 319, 343, 320
479, 320, 343, 344
480, 320, 344, 321
481, 321, 344, 345
482, 321, 345, 322
483, 322, 345, 346
484, 322, 346, 323
485, 323, 346, 347
486, 323, 347, 324
487, 324, 347, 348
488, 324, 348, 325
489, 325, 348, 349
490, 325, 349, 326
491, 326, 349, 350
492, 326, 350, 327
493, 327, 350, 351
494, 327, 351, 328
495, 328, 351, 352
496, 328, 352, 329
497, 329, 352, 353
498, 329, 353, 330
499, 330, 353, 354
500, 330, 354, 165
501, 165, 354, 164
502, 16, 17, 331
503, 331, 17, 355
504, 331, 355, 332
505, 332, 355, 356
506, 332, 356, 333
507, 333, 356, 357
508, 333, 357, 334
509, 334, 357, 358
510, 334, 358, 335
511, 335, 358, 359
512, 335, 359, 336
513, 336, 359, 360
514, 336, 360, 337
515, 337, 360, 361
516, 337, 361, 338
517, 338, 361, 362
518, 338, 362, 339
519, 339, 362, 363
520, 339, 363, 340
521, 340, 363, 364
522, 340, 364, 341
523, 341, 364, 365
524, 341, 365, 342
525, 342, 365, 366
526, 342, 366, 343
527, 343, 366, 367
528, 343, 367, 344
529, 344, 367, 368
530, 344, 368, 345
531, 345, 368, 369
532, 345, 369, 346
533, 346, 369, 370
534, 346, 370, 347
535, 347, 370, 371
536, 347, 371, 348
537, 348, 371, 372
538, 348, 372, 349
539, 349, 372, 373
540, 349, 373, 350
541, 350, 373, 374
542, 350, 374, 351
543, 351, 374, 375
544, 351, 375, 352
545, 352, 375, 376
546, 352, 376, 353
547, 353, 376, 377
548, 353, 377, 354
549, 354, 377, 378
550, 354, 378, 164
551, 164, 378, 163
552, 17, 18, 355
553, 355, 18, 379
554, 355, 379, 356
555, 356, 379, 380
556, 356, 380, 357
557, 357, 380, 381
558, 357, 381, 358
559, 358, 381, 382
560, 358, 382, 359
561, 359, 382, 383
562, 359, 383, 360
563, 360, 383, 384
564, 360, 384, 361
565, 361, 384, 385
566, 361, 385, 362
567, 362, 385, 386
568, 362, 386, 363
569, 363, 386, 387
570, 363, 387, 364
571, 364, 387, 388
572, 364, 388, 365
573, 365, 388, 389
574, 365, 389, 366
575, 366, 389, 390
576, 366, 390, 367
577, 367, 390, 391
578, 367, 391, 368
579, 368, 391, 392
580, 368, 392, 369
581, 369, 392, 393
582, 369, 393, 370
583, 370, 393, 394
584, 370, 394, 371
585, 371, 394, 395
586, 371, 395, 372
587, 372, 395, 396
588, 372, 396, 373
589, 373, 396, 397
590, 373, 397, 374
591, 374, 397, 398
592, 374, 398, 375
593, 375, 398, 399
594, 375, 399, 376
595, 376, 399, 400
596, 376, 400, 377
597, 377, 400, 401
598, 377, 401, 378
599, 378, 401, 402
600, 378, 402, 163
601, 163, 402, 162
602, 18, 3, 379
603, 379, 3, 138
604, 379, 138, 380
605, 380, 138, 139
606, 380, 139, 381
607, 381, 139, 140
608, 381, 140, 382
609, 382, 140, 141
610, 382, 141, 383
611, 383, 141, 142
612, 383, 142, 384
613, 384, 142, 143
614, 384, 143, 385
615, 385, 143, 144
616, 385, 144, 386
617, 386, 144, 145
618, 386, 145, 387
619, 387, 145, 146
620, 387, 146, 388
621, 388, 146, 147
622, 388, 147, 389
623, 389, 147, 148
624, 389, 148, 390
625, 390, 148, 149
626, 390, 149, 391
627, 391, 149, 150
628, 391, 150, 392
629, 392, 150, 151
630, 392, 151, 393
631, 393, 151, 152
632, 393, 152, 394
633, 394, 152, 153
634, 394, 153, 395
635, 395, 153, 154
636, 395, 154, 396
637, 396, 154, 155
638, 396, 155, 397
639, 397, 155, 156
640, 397, 156, 398
641, 398, 156, 157
642, 398, 157, 399
643, 399, 157, 158
644, 399, 158, 400
645, 400, 158, 159
646, 400, 159, 401
647, 401, 159, 160
648, 401, 160, 402
649, 402, 160, 161
650, 402, 161, 162
651, 162, 161, 13
652, 11, 166, 105
653, 105, 166, 403
654, 105, 403, 104
655, 104, 403, 404
656, 104, 404, 103
657, 103, 404, 405
658, 103, 405, 102
659, 102, 405, 406
660, 102, 406, 101
661, 101, 406, 407
662, 101, 407, 100
663, 100, 407, 408
664, 100, 408, 99
665, 99, 408, 409
666, 99, 409, 98
667, 98, 409, 410
668, 98, 410, 97
669, 97, 410, 411
670, 97, 411, 96
671, 96, 411, 412
672, 96, 412, 95
673, 95, 412, 413
674, 95, 413, 94
675, 94, 413, 414
676, 94, 414, 93
677, 93, 414, 415
678, 93, 415, 92
679, 92, 415, 416
680, 92, 416, 91
681, 91, 416, 417
682, 91, 417, 90
683, 90, 417, 418
684, 90, 418, 89
685, 89, 418, 419
686, 89, 419, 88
687, 88, 419, 420
688, 88, 420, 87
689, 87, 420, 421
690, 87, 421, 86
691, 86, 421, 422
692, 86, 422, 85
693, 85, 422, 423
694, 85, 423, 84
695, 84, 423, 424
696, 84, 424, 83
697, 83, 424, 425
698, 83, 425, 82
699, 82, 425, 426
700, 82, 426, 5
701, 5, 426, 26
702, 166, 167, 403
703, 403, 167, 427
704, 403, 427, 404
705, 404, 427, 428
706, 404, 428, 405
707, 405, 428, 429
708, 405, 429, 406
709, 406, 429, 430
710, 406, 430, 407
711, 407, 430, 431
712, 407, 431, 408
713, 408, 431, 432
714, 408, 432, 409
715, 409, 432, 433
716, 409, 433, 410
717, 410, 433, 434
718, 410, 434, 411
719, 411, 434, 435
720, 411, 435, 412
721, 412, 435, 436
722, 412, 436, 413
723, 413, 436, 437
724, 413, 437, 414
725, 414, 437, 438
726, 414, 438, 415
727, 415, 438, 439
728, 415, 439, 416
729, 416, 439, 440
730, 416, 440, 417
731, 417, 440, 441
732, 417, 441, 418
733, 418, 441, 442
734, 418, 442, 419
735, 419, 442, 443
736, 419, 443, 420
737, 420, 443, 444
738, 420, 444, 421
739, 421, 444, 445
740, 421, 445, 422
741, 422, 445, 446
742, 422, 446, 423
743, 423, 446, 447
744, 423, 447, 424
745, 424, 447, 448
746, 424, 448, 425
747, 425, 448, 449
748, 425, 449, 426
749, 426, 449, 450
750, 426, 450, 26
751, 26, 450, 25
752, 167, 168, 427
753, 427, 168, 451
754, 427, 451, 428
755, 428, 451, 452
756, 428, 452, 429
757, 429, 452, 453
758, 429, 453, 430
759, 430, 453, 454
760, 430, 454, 431
761, 431, 454, 455
762, 431, 455, 432
763, 432, 455, 456
764, 432, 456, 433
765, 433, 456, 457
766, 433, 457, 434
767, 434, 457, 458
768, 434, 458, 435
769, 435, 458, 459
770, 435, 459, 436
771, 436, 459, 460
772, 436, 460, 437
773, 437, 460, 461
774, 437, 461, 438
775, 438, 461, 462
776, 438, 462, 439
777, 439, 462, 463
778, 439, 463, 440
779, 440, 463, 464
780, 440, 464, 441
781, 441, 464, 465
782, 441, 465, 442
783, 442, 465, 466
784, 442, 466, 443
785, 443, 466, 467
786, 443, 467, 444
787, 444, 467, 468
788, 444, 468, 445
789, 445, 468, 469
790, 445, 469, 446
791, 446, 469, 470
792, 446, 470, 447
793, 447, 470, 471
794, 447, 471, 448
795, 448, 471, 472
796, 448, 472, 449
797, 449, 472, 473
798, 449, 473, 450
799, 450, 473, 474
800, 450, 474, 25
801, 25, 474, 24
802, 168, 169, 451
803, 451, 169, 475
804, 451, 475, 452
805, 452, 475, 476
806, 452, 476, 453
807, 453, 476, 477
808, 453, 477, 454
809, 454, 477, 478
810, 454, 478, 455
811, 455, 478, 479
812, 455, 479, 456
813, 456, 479, 480
814, 456, 480, 457
815, 457, 480, 481
816, 457, 481, 458
817, 458, 481, 482
818, 458, 482, 459
819, 459, 482, 483
820, 459, 483, 460
821, 460, 483, 484
822, 460, 484, 461
823, 461, 484, 485
824, 461, 485, 462
825, 462, 485, 486
826, 462, 486, 463
827, 463, 486, 487
828, 463, 487, 464
829, 464, 487, 488
830, 464, 488, 465
831, 465, 488, 489
832, 465, 489, 466
833, 466, 489, 490
834, 466, 490, 467
835, 467, 490, 491
836, 467, 491, 468
837, 468, 491, 492
838, 468, 492, 469
839, 469, 492, 493
840, 469, 493, 470
841, 470, 493, 494
842, 470, 494, 471
843, 471, 494, 495
844, 471, 495, 472
845, 472, 495, 496
846, 472, 496, 473
847, 473, 496, 497
848, 473, 497, 474
849, 474, 497, 498
850, 474, 498, 24
851, 24, 498, 23
852, 169, 14, 475
853, 475, 14, 170
854, 475, 170, 476
855, 476, 170, 171
856, 476, 171, 477
857, 477, 171, 172
858, 477, 172, 478
859, 478, 172, 173
860, 478, 173, 479
861, 479, 173, 174
862, 479, 174, 480
863, 480, 174, 175
864, 480, 175, 481
865, 481, 175, 176
866, 481, 176, 482
867, 482, 176, 177
868, 482, 177, 483
869, 483, 177, 178
870, 483, 178, 484
871, 484, 178, 179
872, 484, 179, 485
873, 485, 179, 180
874, 485, 180, 486
875, 486, 180, 181
876, 486, 181, 487
877, 487, 181, 182
878, 487, 182, 488
879, 488, 182, 183
880, 488, 183, 489
881, 489, 183, 184
882, 489, 184, 490
883, 490, 184, 185
884, 490, 185, 491
885, 491, 185, 186
886, 491, 186, 492
887, 492, 186, 187
888, 492, 187, 493
889, 493, 187, 188
890, 493, 188, 494
891, 494, 188, 189
892, 494, 189, 495
893, 495, 189, 190
894, 495, 190, 496
895, 496, 190, 191
896, 496, 191, 497
897, 497, 191, 192
898, 497, 192, 498
899, 498, 192, 193
900, 498, 193, 23
901, 23, 193, 4
902, 4, 22, 23
903, 22, 499, 23
904, 22, 21, 499
905, 21, 500, 499
906, 21, 20, 500
907, 20, 501, 500
908, 20, 19, 501
909, 19, 502, 501
910, 19, 3, 502
911, 3, 18, 502
912, 23, 499, 24
913, 499, 503, 24
914, 499, 500, 503
915, 500, 504, 503
916, 500, 501, 504
917, 501, 505, 504
918, 501, 502, 505
919, 502, 506, 505
920, 502, 18, 506
921, 18, 17, 506
922, 24, 503, 25
923, 503, 507, 25
924, 503, 504, 507
925, 504, 508, 507
926, 504, 505, 508
927, 505, 509, 508
928, 505, 506, 509
929, 506, 510, 509
930, 506, 17, 510
931, 17, 16, 510
932, 25, 507, 26
933, 507, 511, 26
934, 507, 508, 511
935, 508, 512, 511
936, 508, 509, 512
937, 509, 513, 512
938, 509, 510, 513
939, 510, 514, 513
940, 510, 16, 514
941, 16, 15, 514
942, 26, 511, 5
943, 511, 134, 5
944, 511, 512, 134
945, 512, 135, 134
946, 512, 513, 135
947, 513, 136, 135
948, 513, 514, 136
949, 514, 137, 136
950, 514, 15, 137
951, 15, 2, 137
952, 14, 194, 170
953, 194, 515, 170
954, 194, 195, 515
955, 195, 516, 515
956, 195, 196, 516
957, 196, 517, 516
958, 196, 197, 517
959, 197, 518, 517
960, 197, 13, 518
961, 13, 161, 518
962, 170, 515, 171
963, 515, 519, 171
964, 515, 516, 519
965, 516, 520, 519
966, 516, 517, 520
967, 517, 521, 520
968, 517, 518, 521
969, 518, 522, 521
970, 518, 161, 522
971, 161, 160, 522
972, 171, 519, 172
973, 519, 523, 172
974, 519, 520, 523
975, 520, 524, 523
976, 520, 521, 524
977, 521, 525, 524
978, 521, 522, 525
979, 522, 526, 525
980, 522, 160, 526
981, 160, 159, 526
982, 172, 523, 173
983, 523, 527, 173
984, 523, 524, 527
985, 524, 528, 527
986, 524, 525, 528
987, 525, 529, 528
988, 525, 526, 529
989, 526, 530, 529
990, 526, 159, 530
991, 159, 158, 530
992, 173, 527, 174
993, 527, 531, 174
994, 527, 528, 531
995, 528, 532, 531
996, 528, 529, 532
997, 529, 533, 532
998, 529, 530, 533
999, 530, 534, 533
1000, 530, 158, 534
1001, 158, 157, 534
1002, 174, 531, 175
1003, 531, 535, 175
1004, 531, 532, 535
1005, 532, 536, 535
1006, 532, 533, 536
1007, 533, 537, 536
1008, 533, 534, 537
1009, 534, 538, 537
1010, 534, 157, 538
1011, 157, 156, 538
1012, 175, 535, 176
1013, 535, 539, 176
1014, 535, 536, 539
1015, 536, 540, 539
1016, 536, 537, 540
1017, 537, 541, 540
1018, 537, 538, 541
1019, 538, 542, 541
1020, 538, 156, 542
1021, 156, 155, 542
1022, 176, 539, 177
1023, 539, 543, 177
1024, 539, 540, 543
1025, 540, 544, 543
1026, 540, 541, 544
1027, 541, 545, 544
1028, 541, 542, 545
1029, 542, 546, 545
1030, 542, 155, 546
1031, 155, 154, 546
1032, 177, 543, 178
1033, 543, 547, 178
1034, 543, 544, 547
1035, 544, 548, 547
1036, 544, 545, 548
1037, 545, 549, 548
1038, 545, 546, 549
1039, 546, 550, 549
1040, 546, 154, 550
1041, 154, 153, 550
1042, 178, 547, 179
1043, 547, 551, 179
1044, 547, 548, 551
1045, 548, 552, 551
1046, 548, 549, 552
1047, 549, 553, 552
1048, 549, 550, 553
1049, 550, 554, 553
1050, 550, 153, 554
1051, 153, 152, 554
1052, 179, 551, 180
1053, 551, 555, 180
1054, 551, 552, 555
1055, 552, 556, 555
1056, 552, 553, 556
1057, 553, 557, 556
1058, 553, 554, 557
1059, 554, 558, 557
1060, 554, 152, 558
1061, 152, 151, 558
1062, 180, 555, 181
1063, 555, 559, 181
1064, 555, 556, 559
1065, 556, 560, 559
1066, 556, 557, 560
1067, 557, 561, 560
1068, 557, 558, 561
1069, 558, 562, 561
1070, 558, 151, 562
1071, 151, 150, 562
1072, 181, 559, 182
1073, 559, 563, 182
1074, 559, 560, 563
1075, 560, 564, 563
1076, 560, 561, 564
1077, 561, 565, 564
1078, 561, 562, 565
1079, 562, 566, 565
1080, 562, 150, 566
1081, 150, 149, 566
1082, 182, 563, 183
1083, 563, 567, 183
1084, 563, 564, 567
1085, 564, 568, 567
1086, 564, 565, 568
1087, 565, 569, 568
1088, 565, 566, 569
1089, 566, 570, 569
1090, 566, 149, 570
1091, 149, 148, 570
1092, 183, 567, 184
1093, 567, 571, 184
1094, 567, 568, 571
1095, 568, 572, 571
1096, 568, 569, 572
1097, 569, 573, 572
1098, 569, 570, 573
1099, 570, 574, 573
1100, 570, 148, 574
1101, 148, 147, 574
1102, 184, 571, 185
1103, 571, 575, 185
1104, 571, 572, 575
1105, 572, 576, 575
1106, 572, 573, 576
1107, 573, 577, 576
1108, 573, 574, 577
1109, 574, 578, 577
1110, 574, 147, 578
1111, 147, 146, 578
1112, 185, 575, 186
1113, 575, 579, 186
1114, 575, 576, 579
1115, 576, 580, 579
1116, 576, 577, 580
1117, 577, 581, 580
1118, 577, 578, 581
1119, 578, 582, 581
1120, 578, 146, 582
1121, 146, 145, 582
1122, 186, 579, 187
1123, 579, 583, 187
1124, 579, 580, 583
1125, 580, 584, 583
1126, 580, 581, 584
1127, 581, 585, 584
1128, 581, 582, 585
1129, 582, 586, 585
1130, 582, 145, 586
1131, 145, 144, 586
1132, 187, 583, 188
1133, 583, 587, 188
1134, 583, 584, 587
1135, 584, 588, 587
1136, 584, 585, 588
1137, 585, 589, 588
1138, 585, 586, 589
1139, 586, 590, 589
1140, 586, 144, 590
1141, 144, 143, 590
1142, 188, 587, 189
1143, 587, 591, 189
1144, 587, 588, 591
1145, 588, 592, 591
1146, 588, 589, 592
1147, 589, 593, 592
1148, 589, 590, 593
1149, 590, 594, 593
1150, 590, 143, 594
1151, 143, 142, 594
1152, 189, 591, 190
1153, 591, 595, 190
1154, 591, 592, 595
1155, 592, 596, 595
1156, 592, 593, 596
1157, 593, 597, 596
1158, 593, 594, 597
1159, 594, 598, 597
1160, 594, 142, 598
1161, 142, 141, 598
1162, 190, 595, 191
1163, 595, 599, 191
1164, 595, 596, 599
1165, 596, 600, 599
1166, 596, 597, 600
1167, 597, 601, 600
1168, 597, 598, 601
1169, 598, 602, 601
1170, 598, 141, 602
1171, 141, 140, 602
1172, 191, 599, 192
1173, 599, 603, 192
1174, 599, 600, 603
1175, 600, 604, 603
1176, 600, 601, 604
1177, 601, 605, 604
1178, 601, 602, 605
1179, 602, 606, 605
1180, 602, 140, 606
1181, 140, 139, 606
1182, 192, 603, 193
1183, 603, 607, 193
1184, 603, 604, 607
1185, 604, 608, 607
1186, 604, 605, 608
1187, 605, 609, 608
1188, 605, 606, 609
1189, 606, 610, 609
1190, 606, 139, 610
1191, 139, 138, 610
1192, 193, 607, 4
1193, 607, 22, 4
1194, 607, 608, 22
1195, 608, 21, 22
1196, 608, 609, 21
1197, 609, 20, 21
1198, 609, 610, 20
1199, 610, 19, 20
1200, 610, 138, 19
1201, 138, 3, 19
**
** Node sets +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Element sets ++++++++++++++++++++++++++++++++++++++++++++
**
*Elset, Elset=Element_Set-1
902, 903, 904, 905, 906, 907, 908, 909, 910, 911, 912, 913, 914, 915, 916, 917, 
918, 919, 920, 921, 922, 923, 924, 925, 926, 927, 928, 929, 930, 931, 932, 933, 
934, 935, 936, 937, 938, 939, 940, 941, 942, 943, 944, 945, 946, 947, 948, 949, 
950, 951
**
** Surfaces ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Physical constants ++++++++++++++++++++++++++++++++++++++
**
**
** Materials +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Sections ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Pre-tension sections ++++++++++++++++++++++++++++++++++++
**
**
** Constraints +++++++++++++++++++++++++++++++++++++++++++++
**
**
** Surface interactions ++++++++++++++++++++++++++++++++++++
**
**
** Contact pairs +++++++++++++++++++++++++++++++++++++++++++
**
**
** Amplitudes ++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Initial conditions ++++++++++++++++++++++++++++++++++++++
**
**
** Steps +++++++++++++++++++++++++++++++++++++++++++++++++++
**
