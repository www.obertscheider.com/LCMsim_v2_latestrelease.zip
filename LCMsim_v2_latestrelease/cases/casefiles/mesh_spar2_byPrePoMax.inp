1722, 1086, 58, 448
1723, 1086, 448, 437
1724, 437, 448, 50
1725, 58, 516, 438
1726, 438, 516, 1087
1727, 438, 1087, 439
1728, 439, 1087, 1088
1729, 439, 1088, 440
1730, 440, 1088, 1089
1731, 440, 1089, 441
1732, 441, 1089, 1090
1733, 441, 1090, 442
1734, 442, 1090, 1091
1735, 442, 1091, 443
1736, 443, 1091, 1092
1737, 443, 1092, 444
1738, 444, 1092, 1093
1739, 444, 1093, 445
1740, 445, 1093, 1094
1741, 445, 1094, 446
1742, 446, 1094, 1095
1743, 446, 1095, 447
1744, 447, 1095, 1096
1745, 447, 1096, 51
1746, 51, 1096, 449
1747, 516, 67, 1087
1748, 1087, 67, 517
1749, 1087, 517, 1088
1750, 1088, 517, 518
1751, 1088, 518, 1089
1752, 1089, 518, 519
1753, 1089, 519, 1090
1754, 1090, 519, 520
1755, 1090, 520, 1091
1756, 1091, 520, 521
1757, 1091, 521, 1092
1758, 1092, 521, 522
1759, 1092, 522, 1093
1760, 1093, 522, 523
1761, 1093, 523, 1094
1762, 1094, 523, 524
1763, 1094, 524, 1095
1764, 1095, 524, 525
1765, 1095, 525, 1096
1766, 1096, 525, 526
1767, 1096, 526, 449
1768, 449, 526, 59
1769, 64, 527, 461
1770, 527, 1097, 461
1771, 527, 528, 1097
1772, 528, 1098, 1097
1773, 528, 68, 1098
1774, 68, 529, 1098
1775, 461, 1097, 56
1776, 1097, 462, 56
1777, 1097, 1098, 462
1778, 1098, 463, 462
1779, 1098, 529, 463
1780, 529, 65, 463
1781, 57, 494, 515
1782, 494, 1099, 515
1783, 494, 493, 1099
1784, 493, 1100, 1099
1785, 493, 492, 1100
1786, 492, 1101, 1100
1787, 492, 491, 1101
1788, 491, 1102, 1101
1789, 491, 490, 1102
1790, 490, 1103, 1102
1791, 490, 489, 1103
1792, 489, 1104, 1103
1793, 489, 488, 1104
1794, 488, 1105, 1104
1795, 488, 487, 1105
1796, 487, 1106, 1105
1797, 487, 486, 1106
1798, 486, 1107, 1106
1799, 486, 485, 1107
1800, 485, 1108, 1107
1801, 485, 484, 1108
1802, 484, 1109, 1108
1803, 484, 483, 1109
1804, 483, 1110, 1109
1805, 483, 482, 1110
1806, 482, 1111, 1110
1807, 482, 481, 1111
1808, 481, 1112, 1111
1809, 481, 480, 1112
1810, 480, 1113, 1112
1811, 480, 479, 1113
1812, 479, 1114, 1113
1813, 479, 478, 1114
1814, 478, 1115, 1114
1815, 478, 477, 1115
1816, 477, 1116, 1115
1817, 477, 476, 1116
1818, 476, 1117, 1116
1819, 476, 475, 1117
1820, 475, 1118, 1117
1821, 475, 474, 1118
1822, 474, 1119, 1118
1823, 474, 473, 1119
1824, 473, 1120, 1119
1825, 473, 472, 1120
1826, 472, 1121, 1120
1827, 472, 471, 1121
1828, 471, 1122, 1121
1829, 471, 470, 1122
1830, 470, 1123, 1122
1831, 470, 469, 1123
1832, 469, 1124, 1123
1833, 469, 468, 1124
1834, 468, 1125, 1124
1835, 468, 467, 1125
1836, 467, 1126, 1125
1837, 467, 466, 1126
1838, 466, 1127, 1126
1839, 466, 465, 1127
1840, 465, 1128, 1127
1841, 465, 464, 1128
1842, 464, 1129, 1128
1843, 464, 65, 1129
1844, 65, 530, 1129
1845, 515, 1099, 66
1846, 1099, 561, 66
1847, 1099, 1100, 561
1848, 1100, 560, 561
1849, 1100, 1101, 560
1850, 1101, 559, 560
1851, 1101, 1102, 559
1852, 1102, 558, 559
1853, 1102, 1103, 558
1854, 1103, 557, 558
1855, 1103, 1104, 557
1856, 1104, 556, 557
1857, 1104, 1105, 556
1858, 1105, 555, 556
1859, 1105, 1106, 555
1860, 1106, 554, 555
1861, 1106, 1107, 554
1862, 1107, 553, 554
1863, 1107, 1108, 553
1864, 1108, 552, 553
1865, 1108, 1109, 552
1866, 1109, 551, 552
1867, 1109, 1110, 551
1868, 1110, 550, 551
1869, 1110, 1111, 550
1870, 1111, 549, 550
1871, 1111, 1112, 549
1872, 1112, 548, 549
1873, 1112, 1113, 548
1874, 1113, 547, 548
1875, 1113, 1114, 547
1876, 1114, 546, 547
1877, 1114, 1115, 546
1878, 1115, 545, 546
1879, 1115, 1116, 545
1880, 1116, 544, 545
1881, 1116, 1117, 544
1882, 1117, 543, 544
1883, 1117, 1118, 543
1884, 1118, 542, 543
1885, 1118, 1119, 542
1886, 1119, 541, 542
1887, 1119, 1120, 541
1888, 1120, 540, 541
1889, 1120, 1121, 540
1890, 1121, 539, 540
1891, 1121, 1122, 539
1892, 1122, 538, 539
1893, 1122, 1123, 538
1894, 1123, 537, 538
1895, 1123, 1124, 537
1896, 1124, 536, 537
1897, 1124, 1125, 536
1898, 1125, 535, 536
1899, 1125, 1126, 535
1900, 1126, 534, 535
1901, 1126, 1127, 534
1902, 1127, 533, 534
1903, 1127, 1128, 533
1904, 1128, 532, 533
1905, 1128, 1129, 532
1906, 1129, 531, 532
1907, 1129, 530, 531
1908, 530, 69, 531
1909, 66, 562, 495
1910, 562, 1130, 495
1911, 562, 70, 1130
1912, 70, 563, 1130
1913, 495, 1130, 496
1914, 1130, 1131, 496
1915, 1130, 563, 1131
1916, 563, 564, 1131
1917, 496, 1131, 497
1918, 1131, 1132, 497
1919, 1131, 564, 1132
1920, 564, 565, 1132
1921, 497, 1132, 498
1922, 1132, 1133, 498
1923, 1132, 565, 1133
1924, 565, 566, 1133
1925, 498, 1133, 499
1926, 1133, 1134, 499
1927, 1133, 566, 1134
1928, 566, 567, 1134
1929, 499, 1134, 500
1930, 1134, 1135, 500
1931, 1134, 567, 1135
1932, 567, 568, 1135
1933, 500, 1135, 501
1934, 1135, 1136, 501
1935, 1135, 568, 1136
1936, 568, 569, 1136
1937, 501, 1136, 502
1938, 1136, 1137, 502
1939, 1136, 569, 1137
1940, 569, 570, 1137
1941, 502, 1137, 503
1942, 1137, 1138, 503
1943, 1137, 570, 1138
1944, 570, 571, 1138
1945, 503, 1138, 504
1946, 1138, 1139, 504
1947, 1138, 571, 1139
1948, 571, 572, 1139
1949, 504, 1139, 505
1950, 1139, 1140, 505
1951, 1139, 572, 1140
1952, 572, 573, 1140
1953, 505, 1140, 506
1954, 1140, 1141, 506
1955, 1140, 573, 1141
1956, 573, 574, 1141
1957, 506, 1141, 507
1958, 1141, 1142, 507
1959, 1141, 574, 1142
1960, 574, 575, 1142
1961, 507, 1142, 508
1962, 1142, 1143, 508
1963, 1142, 575, 1143
1964, 575, 576, 1143
1965, 508, 1143, 509
1966, 1143, 1144, 509
1967, 1143, 576, 1144
1968, 576, 577, 1144
1969, 509, 1144, 510
1970, 1144, 1145, 510
1971, 1144, 577, 1145
1972, 577, 578, 1145
1973, 510, 1145, 511
1974, 1145, 1146, 511
1975, 1145, 578, 1146
1976, 578, 579, 1146
1977, 511, 1146, 512
1978, 1146, 1147, 512
1979, 1146, 579, 1147
1980, 579, 580, 1147
1981, 512, 1147, 513
1982, 1147, 1148, 513
1983, 1147, 580, 1148
1984, 580, 581, 1148
1985, 513, 1148, 514
1986, 1148, 1149, 514
1987, 1148, 581, 1149
1988, 581, 582, 1149
1989, 514, 1149, 58
1990, 1149, 516, 58
1991, 1149, 582, 516
1992, 582, 67, 516
1993, 65, 529, 530
1994, 529, 1150, 530
1995, 529, 68, 1150
1996, 68, 583, 1150
1997, 530, 1150, 69
1998, 1150, 584, 69
1999, 1150, 583, 584
2000, 583, 71, 584
2001, 69, 585, 531
2002, 531, 585, 1151
2003, 531, 1151, 532
2004, 532, 1151, 1152
2005, 532, 1152, 533
2006, 533, 1152, 1153
2007, 533, 1153, 534
2008, 534, 1153, 1154
2009, 534, 1154, 535
2010, 535, 1154, 1155
2011, 535, 1155, 536
2012, 536, 1155, 1156
2013, 536, 1156, 537
2014, 537, 1156, 1157
2015, 537, 1157, 538
2016, 538, 1157, 1158
2017, 538, 1158, 539
2018, 539, 1158, 1159
2019, 539, 1159, 540
2020, 540, 1159, 1160
2021, 540, 1160, 541
2022, 541, 1160, 1161
2023, 541, 1161, 542
2024, 542, 1161, 1162
2025, 542, 1162, 543
2026, 543, 1162, 1163
2027, 543, 1163, 544
2028, 544, 1163, 1164
2029, 544, 1164, 545
2030, 545, 1164, 1165
2031, 545, 1165, 546
2032, 546, 1165, 1166
2033, 546, 1166, 547
2034, 547, 1166, 1167
2035, 547, 1167, 548
2036, 548, 1167, 1168
2037, 548, 1168, 549
2038, 549, 1168, 1169
2039, 549, 1169, 550
2040, 550, 1169, 1170
2041, 550, 1170, 551
2042, 551, 1170, 1171
2043, 551, 1171, 552
2044, 552, 1171, 1172
2045, 552, 1172, 553
2046, 553, 1172, 1173
2047, 553, 1173, 554
2048, 554, 1173, 1174
2049, 554, 1174, 555
2050, 555, 1174, 1175
2051, 555, 1175, 556
2052, 556, 1175, 1176
2053, 556, 1176, 557
2054, 557, 1176, 1177
2055, 557, 1177, 558
2056, 558, 1177, 1178
2057, 558, 1178, 559
2058, 559, 1178, 1179
2059, 559, 1179, 560
2060, 560, 1179, 1180
2061, 560, 1180, 561
2062, 561, 1180, 1181
2063, 561, 1181, 66
2064, 66, 1181, 562
2065, 585, 72, 1151
2066, 1151, 72, 586
2067, 1151, 586, 1152
2068, 1152, 586, 587
2069, 1152, 587, 1153
2070, 1153, 587, 588
2071, 1153, 588, 1154
2072, 1154, 588, 589
2073, 1154, 589, 1155
2074, 1155, 589, 590
2075, 1155, 590, 1156
2076, 1156, 590, 591
2077, 1156, 591, 1157
2078, 1157, 591, 592
2079, 1157, 592, 1158
2080, 1158, 592, 593
2081, 1158, 593, 1159
2082, 1159, 593, 594
2083, 1159, 594, 1160
2084, 1160, 594, 595
2085, 1160, 595, 1161
2086, 1161, 595, 596
2087, 1161, 596, 1162
2088, 1162, 596, 597
2089, 1162, 597, 1163
2090, 1163, 597, 598
2091, 1163, 598, 1164
2092, 1164, 598, 599
2093, 1164, 599, 1165
2094, 1165, 599, 600
2095, 1165, 600, 1166
2096, 1166, 600, 601
2097, 1166, 601, 1167
2098, 1167, 601, 602
2099, 1167, 602, 1168
2100, 1168, 602, 603
2101, 1168, 603, 1169
2102, 1169, 603, 604
2103, 1169, 604, 1170
2104, 1170, 604, 605
2105, 1170, 605, 1171
2106, 1171, 605, 606
2107, 1171, 606, 1172
2108, 1172, 606, 607
2109, 1172, 607, 1173
2110, 1173, 607, 608
2111, 1173, 608, 1174
2112, 1174, 608, 609
2113, 1174, 609, 1175
2114, 1175, 609, 610
2115, 1175, 610, 1176
2116, 1176, 610, 611
2117, 1176, 611, 1177
2118, 1177, 611, 612
2119, 1177, 612, 1178
2120, 1178, 612, 613
2121, 1178, 613, 1179
2122, 1179, 613, 614
2123, 1179, 614, 1180
2124, 1180, 614, 615
2125, 1180, 615, 1181
2126, 1181, 615, 616
2127, 1181, 616, 562
2128, 562, 616, 70
2129, 71, 617, 584
2130, 617, 1182, 584
2131, 617, 73, 1182
2132, 73, 618, 1182
2133, 584, 1182, 69
2134, 1182, 585, 69
2135, 1182, 618, 585
2136, 618, 72, 585
**
** Node sets +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Element sets ++++++++++++++++++++++++++++++++++++++++++++
**
**
** Surfaces ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Physical constants ++++++++++++++++++++++++++++++++++++++
**
**
** Materials +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Sections ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Pre-tension sections ++++++++++++++++++++++++++++++++++++
**
**
** Constraints +++++++++++++++++++++++++++++++++++++++++++++
**
**
** Surface interactions ++++++++++++++++++++++++++++++++++++
**
**
** Contact pairs +++++++++++++++++++++++++++++++++++++++++++
**
**
** Amplitudes ++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Initial conditions ++++++++++++++++++++++++++++++++++++++
**
**
** Steps +++++++++++++++++++++++++++++++++++++++++++++++++++
**
