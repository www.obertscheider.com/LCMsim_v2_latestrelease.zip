**
** Heading +++++++++++++++++++++++++++++++++++++++++++++++++
**
*Heading
Hash: Vayd4FGJ, Date: 01/03/2024, Unit system: M_KG_S_C
**
** Nodes +++++++++++++++++++++++++++++++++++++++++++++++++++
**
*Node
1, 1.30558006E+001, 2.07338173E-001, -1.39109750E+000
2, 1.30270435E+001, 2.04988604E-001, -1.39058266E+000
3, 1.29635604E+001, 1.77333621E-001, -1.58063785E+000
4, 1.29920516E+001, 1.80339432E-001, -1.58063741E+000
5, 1.31211306E+001, 2.73908222E-001, -1.21246190E+000
6, 1.30925618E+001, 2.71365254E-001, -1.21133746E+000
7, 1.30186093E+001, 1.96634229E-001, -1.38966719E+000
8, 1.29555098E+001, 1.68823779E-001, -1.58063524E+000
9, 1.29499904E+001, 1.75045519E-001, -1.62383074E+000
10, 1.29789479E+001, 1.78184628E-001, -1.62200928E+000
11, 1.31860388E+001, 3.67611857E-001, -1.04582119E+000
12, 1.31574072E+001, 3.64380791E-001, -1.04376574E+000
13, 1.30839493E+001, 2.62857320E-001, -1.20945348E+000
14, 1.30137418E+001, 1.08457428E-001, -1.38081919E+000
15, 1.29543749E+001, 7.34251710E-002, -1.58063020E+000
16, 1.29546638E+001, 8.24891367E-002, -1.58068265E+000
17, 1.29550721E+001, 1.57478417E-001, -1.58055031E+000
18, 1.29420138E+001, 1.66466941E-001, -1.62434213E+000
19, 1.33314882E+001, 5.86361578E-001, -7.39359905E-001
20, 1.33022705E+001, 5.82987900E-001, -7.35976844E-001
21, 1.31490460E+001, 3.55877838E-001, -1.04097020E+000
22, 1.30768261E+001, 1.82198060E-001, -1.19309864E+000
23, 1.30217553E+001, 9.98697358E-002, -1.38002847E+000
24, 1.29627984E+001, 6.50098209E-002, -1.58063788E+000
25, 1.29218409E+001, 8.25151559E-002, -1.69509844E+000
26, 1.29216843E+001, 1.57457534E-001, -1.69511110E+000
27, 1.29414070E+001, 1.57402012E-001, -1.62676929E+000
28, 1.29516930E+001, 7.28282926E-002, -1.59098611E+000
29, 1.29516981E+001, 8.24274269E-002, -1.59163931E+000
30, 1.36261954E+001, 9.31173171E-001, -3.39783241E-001
31, 1.35933356E+001, 9.29570882E-001, -3.36425486E-001
32, 1.32942221E+001, 5.75191360E-001, -7.31473873E-001
33, 1.31447253E+001, 2.82389642E-001, -1.01948291E+000
34, 1.30846617E+001, 1.73490698E-001, -1.19151078E+000
35, 1.30491978E+001, 9.88745797E-002, -1.38021543E+000
36, 1.29899708E+001, 6.44220933E-002, -1.58063775E+000
37, 1.29596212E+001, 6.43547880E-002, -1.59204931E+000
38, 1.36520571E+001, 9.55261427E-001, -3.14065390E-001
39, 1.36186292E+001, 9.53668273E-001, -3.10777315E-001
40, 1.35863382E+001, 9.25144647E-001, -3.28679755E-001
41, 1.32933100E+001, 5.21072075E-001, -7.03355930E-001
42, 1.31528509E+001, 2.74076145E-001, -1.01735321E+000
43, 1.31121242E+001, 1.72607866E-001, -1.19193393E+000
44, 1.36114751E+001, 9.49294107E-001, -3.03111289E-001
45, 1.35926634E+001, 9.10413623E-001, -3.03204877E-001
46, 1.33018460E+001, 5.13605662E-001, -6.99997095E-001
47, 1.31803943E+001, 2.73914059E-001, -1.01841420E+000
48, 1.36169899E+001, 9.35924005E-001, -2.79975842E-001
49, 1.36043186E+001, 9.06162074E-001, -2.96017064E-001
50, 1.33299701E+001, 5.13767477E-001, -7.01643199E-001
51, 1.36287562E+001, 9.31679489E-001, -2.72815319E-001
52, 1.36366419E+001, 9.06062563E-001, -2.96331091E-001
53, 1.36615030E+001, 9.31571550E-001, -2.73087411E-001
54, 1.30414220E+001, 2.06163388E-001, -1.39084008E+000
55, 1.30210873E+001, 2.01302425E-001, -1.40760247E+000
56, 1.30151651E+001, 1.97849104E-001, -1.42468286E+000
57, 1.30092779E+001, 1.94629241E-001, -1.44182085E+000
58, 1.30034266E+001, 1.91643398E-001, -1.45901344E+000
59, 1.29976124E+001, 1.88892096E-001, -1.47625765E+000
60, 1.29918361E+001, 1.86375814E-001, -1.49355046E+000
61, 1.29860989E+001, 1.84094991E-001, -1.51088886E+000
62, 1.29804018E+001, 1.82050025E-001, -1.52826984E+000
63, 1.29747456E+001, 1.80241271E-001, -1.54569035E+000
64, 1.29691315E+001, 1.78669045E-001, -1.56314737E+000
65, 1.29778060E+001, 1.78836527E-001, -1.58063763E+000
66, 1.29976585E+001, 1.81652303E-001, -1.56320453E+000
67, 1.30033059E+001, 1.83194468E-001, -1.54580352E+000
68, 1.30089929E+001, 1.84965676E-001, -1.52843725E+000
69, 1.30147186E+001, 1.86965635E-001, -1.51110856E+000
70, 1.30204819E+001, 1.89194019E-001, -1.49382028E+000
71, 1.30262820E+001, 1.91650463E-001, -1.47657525E+000
72, 1.30321179E+001, 1.94334562E-001, -1.45937630E+000
73, 1.30379887E+001, 1.97245879E-001, -1.44222624E+000
74, 1.30438934E+001, 2.00383935E-001, -1.42512789E+000
75, 1.30498310E+001, 2.03748217E-001, -1.40808404E+000
76, 1.31068462E+001, 2.72636738E-001, -1.21189968E+000
77, 1.30867533E+001, 2.63649144E-001, -1.22700394E+000
78, 1.30809084E+001, 2.56261666E-001, -1.24281464E+000
79, 1.30750295E+001, 2.49205658E-001, -1.25876350E+000
80, 1.30691187E+001, 2.42483832E-001, -1.27484439E+000
81, 1.30631783E+001, 2.36098768E-001, -1.29105113E+000
82, 1.30572107E+001, 2.30052920E-001, -1.30737749E+000
83, 1.30512180E+001, 2.24348611E-001, -1.32381720E+000
84, 1.30452026E+001, 2.18988032E-001, -1.34036395E+000
85, 1.30391669E+001, 2.13973243E-001, -1.35701138E+000
86, 1.30331131E+001, 2.09306169E-001, -1.37375309E+000
87, 1.30618630E+001, 2.11577236E-001, -1.37429428E+000
88, 1.30679085E+001, 2.16185745E-001, -1.35758248E+000
89, 1.30739345E+001, 2.21161716E-001, -1.34096929E+000
90, 1.30799384E+001, 2.26503005E-001, -1.32446187E+000
91, 1.30859176E+001, 2.32207314E-001, -1.30806732E+000
92, 1.30918695E+001, 2.38272186E-001, -1.29179271E+000
93, 1.30977915E+001, 2.44695009E-001, -1.27564503E+000
94, 1.31036812E+001, 2.51473018E-001, -1.25963125E+000
95, 1.31095360E+001, 2.58603295E-001, -1.24375825E+000
96, 1.31153533E+001, 2.66082770E-001, -1.22803288E+000
97, 1.30126970E+001, 1.92973199E-001, -1.40678106E+000
98, 1.30068172E+001, 1.89537287E-001, -1.42395267E+000
99, 1.30009706E+001, 1.86327046E-001, -1.44117924E+000
100, 1.29951583E+001, 1.83342995E-001, -1.45845799E+000
101, 1.29893812E+001, 1.80585616E-001, -1.47578614E+000
102, 1.29836403E+001, 1.78055352E-001, -1.49316088E+000
103, 1.29779364E+001, 1.75752613E-001, -1.51057942E+000
104, 1.29722705E+001, 1.73677770E-001, -1.52803895E+000
105, 1.29666435E+001, 1.71831157E-001, -1.54553664E+000
106, 1.29610563E+001, 1.70213073E-001, -1.56306968E+000
107, 1.29579351E+001, 1.74592371E-001, -1.58062413E+000
108, 1.30212988E+001, 2.02339496E-001, -1.39025395E+000
109, 1.29644692E+001, 1.76615073E-001, -1.62292001E+000
110, 1.29833158E+001, 1.78902896E-001, -1.60821865E+000
111, 1.29876837E+001, 1.79621164E-001, -1.59442803E+000
112, 1.29590371E+001, 1.76570921E-001, -1.59503548E+000
113, 1.29545137E+001, 1.75808220E-001, -1.60943311E+000
114, 1.31717230E+001, 3.65996324E-001, -1.04479347E+000
115, 1.31513535E+001, 3.55336600E-001, -1.05860119E+000
116, 1.31453305E+001, 3.46408422E-001, -1.07351914E+000
117, 1.31393384E+001, 3.37596817E-001, -1.08851866E+000
118, 1.31333776E+001, 3.28902335E-001, -1.10359881E+000
119, 1.31274486E+001, 3.20325523E-001, -1.11875864E+000
120, 1.31215517E+001, 3.11866916E-001, -1.13399720E+000
121, 1.31156873E+001, 3.03527046E-001, -1.14931355E+000
122, 1.31098558E+001, 2.95306433E-001, -1.16470671E+000
123, 1.31040574E+001, 2.87205593E-001, -1.18017573E+000
124, 1.30982926E+001, 2.79225033E-001, -1.19571964E+000
125, 1.31268597E+001, 2.81847157E-001, -1.19693013E+000
126, 1.31326242E+001, 2.89903517E-001, -1.18147208E+000
127, 1.31384238E+001, 2.98076815E-001, -1.16608871E+000
128, 1.31442580E+001, 3.06366553E-001, -1.15078095E+000
129, 1.31501266E+001, 3.14772227E-001, -1.13554973E+000
130, 1.31560291E+001, 3.23293328E-001, -1.12039597E+000
131, 1.31619653E+001, 3.31929336E-001, -1.10532060E+000
132, 1.31679347E+001, 3.40679729E-001, -1.09032453E+000
133, 1.31739370E+001, 3.49543973E-001, -1.07540866E+000
134, 1.31799718E+001, 3.58521531E-001, -1.06057392E+000
135, 1.30781384E+001, 2.55252851E-001, -1.22524865E+000
136, 1.30722957E+001, 2.47958473E-001, -1.24117778E+000
137, 1.30664232E+001, 2.40976648E-001, -1.25723547E+000
138, 1.30605229E+001, 2.34309733E-001, -1.27341633E+000
139, 1.30545967E+001, 2.27959978E-001, -1.28971488E+000
140, 1.30486467E+001, 2.21929526E-001, -1.30612562E+000
141, 1.30426748E+001, 2.16220412E-001, -1.32264302E+000
142, 1.30366831E+001, 2.10834562E-001, -1.33926150E+000
143, 1.30306736E+001, 2.05773795E-001, -1.35597545E+000
144, 1.30246483E+001, 2.01039818E-001, -1.37277924E+000
145, 1.30867318E+001, 2.68599419E-001, -1.21064059E+000
146, 1.30169868E+001, 1.67241962E-001, -1.38671785E+000
147, 1.30153643E+001, 1.37849695E-001, -1.38376852E+000
148, 1.30081952E+001, 1.03599563E-001, -1.39859698E+000
149, 1.30026732E+001, 9.90726001E-002, -1.41646953E+000
150, 1.29971777E+001, 9.48779933E-002, -1.43443110E+000
151, 1.29917104E+001, 9.10170915E-002, -1.45247591E+000
152, 1.29862730E+001, 8.74911359E-002, -1.47059817E+000
153, 1.29808673E+001, 8.43012601E-002, -1.48879204E+000
154, 1.29754951E+001, 8.14484895E-002, -1.50705168E+000
155, 1.29701580E+001, 7.89337414E-002, -1.52537121E+000
156, 1.29648578E+001, 7.67578241E-002, -1.54374475E+000
157, 1.29595962E+001, 7.49214371E-002, -1.56216638E+000
158, 1.29547659E+001, 1.01236457E-001, -1.58064957E+000
159, 1.29548680E+001, 1.19983777E-001, -1.58061648E+000
160, 1.29549701E+001, 1.38731097E-001, -1.58058340E+000
161, 1.29510112E+001, 1.68038166E-001, -1.59520420E+000
162, 1.29465125E+001, 1.67252554E-001, -1.60977317E+000
163, 1.29443563E+001, 1.72265294E-001, -1.62373005E+000
164, 1.31923630E+001, 3.77321852E-001, -1.03046887E+000
165, 1.31987490E+001, 3.87105003E-001, -1.01518876E+000
166, 1.32051966E+001, 3.96960927E-001, -9.99981461E-001
167, 1.32117056E+001, 4.06889243E-001, -9.84847556E-001
168, 1.32182756E+001, 4.16889564E-001, -9.69787637E-001
169, 1.32249065E+001, 4.26961501E-001, -9.54802290E-001
170, 1.32315979E+001, 4.37104662E-001, -9.39892096E-001
171, 1.32383496E+001, 4.47318652E-001, -9.25057637E-001
172, 1.32451614E+001, 4.57603075E-001, -9.10299490E-001
173, 1.32520330E+001, 4.67957531E-001, -8.95618227E-001
174, 1.32589641E+001, 4.78381616E-001, -8.81014421E-001
175, 1.32659545E+001, 4.88874925E-001, -8.66488640E-001
176, 1.32730038E+001, 4.99437050E-001, -8.52041447E-001
177, 1.32801118E+001, 5.10067581E-001, -8.37673406E-001
178, 1.32872783E+001, 5.20766103E-001, -8.23385075E-001
179, 1.32945029E+001, 5.31532201E-001, -8.09177010E-001
180, 1.33017854E+001, 5.42365456E-001, -7.95049764E-001
181, 1.33091254E+001, 5.53265446E-001, -7.81003885E-001
182, 1.33165228E+001, 5.64231748E-001, -7.67039921E-001
183, 1.33239772E+001, 5.75263935E-001, -7.53158414E-001
184, 1.33168794E+001, 5.84674739E-001, -7.37668374E-001
185, 1.32948019E+001, 5.71872918E-001, -7.49832594E-001
186, 1.32873886E+001, 5.60825765E-001, -7.63772005E-001
187, 1.32800308E+001, 5.49846878E-001, -7.77794527E-001
188, 1.32727288E+001, 5.38936689E-001, -7.91899608E-001
189, 1.32654830E+001, 5.28095629E-001, -8.06086690E-001
190, 1.32582935E+001, 5.17324127E-001, -8.20355214E-001
191, 1.32511607E+001, 5.06622607E-001, -8.34704616E-001
192, 1.32440849E+001, 4.95991491E-001, -8.49134331E-001
193, 1.32370664E+001, 4.85431198E-001, -8.63643789E-001
194, 1.32301053E+001, 4.74942147E-001, -8.78232417E-001
195, 1.32232021E+001, 4.64524750E-001, -8.92899640E-001
196, 1.32163569E+001, 4.54179418E-001, -9.07644878E-001
197, 1.32095701E+001, 4.43906560E-001, -9.22467551E-001
198, 1.32028418E+001, 4.33706581E-001, -9.37367074E-001
199, 1.31961725E+001, 4.23579884E-001, -9.52342857E-001
200, 1.31895623E+001, 4.13526869E-001, -9.67394311E-001
201, 1.31830114E+001, 4.03547931E-001, -9.82520841E-001
202, 1.31765203E+001, 3.93643465E-001, -9.97721850E-001
203, 1.31700890E+001, 3.83813861E-001, -1.01299674E+000
204, 1.31637179E+001, 3.74059508E-001, -1.02834490E+000
205, 1.31516679E+001, 3.61546462E-001, -1.04271939E+000
206, 1.31429711E+001, 3.46824282E-001, -1.05588589E+000
207, 1.31369264E+001, 3.37888498E-001, -1.07088467E+000
208, 1.31309124E+001, 3.29071052E-001, -1.08596557E+000
209, 1.31249295E+001, 3.20372506E-001, -1.10112765E+000
210, 1.31189779E+001, 3.11793411E-001, -1.11636994E+000
211, 1.31130582E+001, 3.03334313E-001, -1.13169147E+000
212, 1.31071706E+001, 2.94995750E-001, -1.14709127E+000
213, 1.31013155E+001, 2.86778251E-001, -1.16256835E+000
214, 1.30954934E+001, 2.78682338E-001, -1.17812174E+000
215, 1.30897045E+001, 2.70708525E-001, -1.19375045E+000
216, 1.30815749E+001, 2.35970900E-001, -1.20400187E+000
217, 1.30792005E+001, 2.09084480E-001, -1.19855025E+000
218, 1.30708957E+001, 1.73814994E-001, -1.20937768E+000
219, 1.30649978E+001, 1.65759464E-001, -1.22583294E+000
220, 1.30591347E+001, 1.58034501E-001, -1.24245825E+000
221, 1.30533085E+001, 1.50643013E-001, -1.25924735E+000
222, 1.30475214E+001, 1.43587779E-001, -1.27619391E+000
223, 1.30417757E+001, 1.36871456E-001, -1.29329157E+000
224, 1.30360734E+001, 1.30496570E-001, -1.31053388E+000
225, 1.30304168E+001, 1.24465520E-001, -1.32791436E+000
226, 1.30248079E+001, 1.18780575E-001, -1.34542648E+000
227, 1.30192489E+001, 1.13443875E-001, -1.36306363E+000
228, 1.30162548E+001, 9.50137410E-002, -1.39788164E+000
229, 1.30107771E+001, 9.04913863E-002, -1.41582922E+000
230, 1.30053242E+001, 8.63041375E-002, -1.43386541E+000
231, 1.29998976E+001, 8.24533518E-002, -1.45198435E+000
232, 1.29944993E+001, 7.89402772E-002, -1.47018017E+000
233, 1.29891309E+001, 7.57660524E-002, -1.48844698E+000
234, 1.29837941E+001, 7.29317061E-002, -1.50677885E+000
235, 1.29784908E+001, 7.04381570E-002, -1.52516984E+000
236, 1.29732226E+001, 6.82862133E-002, -1.54361400E+000
237, 1.29679912E+001, 6.64765724E-002, -1.56210535E+000
238, 1.29568671E+001, 6.74962850E-002, -1.58062515E+000
239, 1.30159335E+001, 1.02488171E-001, -1.38022532E+000
240, 1.29218017E+001, 1.01250751E-001, -1.69510161E+000
241, 1.29217626E+001, 1.19986345E-001, -1.69510477E+000
242, 1.29217234E+001, 1.38721940E-001, -1.69510794E+000
243, 1.29266150E+001, 1.57443654E-001, -1.67802565E+000
244, 1.29315456E+001, 1.57429773E-001, -1.66094019E+000
245, 1.29364763E+001, 1.57415893E-001, -1.64385474E+000
246, 1.29467219E+001, 8.24420484E-002, -1.60888250E+000
247, 1.29417457E+001, 8.24566699E-002, -1.62612569E+000
248, 1.29367695E+001, 8.24712914E-002, -1.64336888E+000
249, 1.29317933E+001, 8.24859129E-002, -1.66061206E+000
250, 1.29268171E+001, 8.25005344E-002, -1.67785525E+000
251, 1.36097655E+001, 9.30372026E-001, -3.38104364E-001
252, 1.35824666E+001, 9.19016464E-001, -3.47740834E-001
253, 1.35717066E+001, 9.08438473E-001, -3.59138118E-001
254, 1.35610563E+001, 8.97837476E-001, -3.70616726E-001
255, 1.35505163E+001, 8.87214042E-001, -3.82176045E-001
256, 1.35400870E+001, 8.76568740E-001, -3.93815454E-001
257, 1.35297690E+001, 8.65902141E-001, -4.05534329E-001
258, 1.35195630E+001, 8.55214816E-001, -4.17332042E-001
259, 1.35094694E+001, 8.44507338E-001, -4.29207961E-001
260, 1.34994888E+001, 8.33780281E-001, -4.41161449E-001
261, 1.34896217E+001, 8.23034221E-001, -4.53191866E-001
262, 1.34798686E+001, 8.12269732E-001, -4.65298567E-001
263, 1.34702301E+001, 8.01487393E-001, -4.77480902E-001
264, 1.34607068E+001, 7.90687780E-001, -4.89738219E-001
265, 1.34512990E+001, 7.79871474E-001, -5.02069860E-001
266, 1.34420073E+001, 7.69039053E-001, -5.14475166E-001
267, 1.34328322E+001, 7.58191099E-001, -5.26953470E-001
268, 1.34237742E+001, 7.47328192E-001, -5.39504104E-001
269, 1.34148338E+001, 7.36450915E-001, -5.52126395E-001
270, 1.34060114E+001, 7.25559852E-001, -5.64819667E-001
271, 1.33973076E+001, 7.14655585E-001, -5.77583240E-001
272, 1.33887228E+001, 7.03738699E-001, -5.90416428E-001
273, 1.33802574E+001, 6.92809780E-001, -6.03318545E-001
274, 1.33719120E+001, 6.81869413E-001, -6.16288899E-001
275, 1.33636869E+001, 6.70918185E-001, -6.29326794E-001
276, 1.33555826E+001, 6.59956683E-001, -6.42431531E-001
277, 1.33475995E+001, 6.48985494E-001, -6.55602409E-001
278, 1.33397381E+001, 6.38005206E-001, -6.68838722E-001
279, 1.33319988E+001, 6.27016408E-001, -6.82139759E-001
280, 1.33243820E+001, 6.16019688E-001, -6.95504807E-001
281, 1.33168880E+001, 6.05015637E-001, -7.08933152E-001
282, 1.33095174E+001, 5.94004844E-001, -7.22424072E-001
283, 1.33388128E+001, 5.97371988E-001, -7.25808094E-001
284, 1.33462635E+001, 6.08373258E-001, -7.12317811E-001
285, 1.33538401E+001, 6.19364779E-001, -6.98889800E-001
286, 1.33615421E+001, 6.30345944E-001, -6.85524803E-001
287, 1.33693690E+001, 6.41316148E-001, -6.72223557E-001
288, 1.33773205E+001, 6.52274783E-001, -6.58986798E-001
289, 1.33853961E+001, 6.63221245E-001, -6.45815257E-001
290, 1.33935953E+001, 6.74154930E-001, -6.32709660E-001
291, 1.34019178E+001, 6.85075233E-001, -6.19670733E-001
292, 1.34103629E+001, 6.95981551E-001, -6.06699195E-001
293, 1.34189304E+001, 7.06873282E-001, -5.93795762E-001
294, 1.34276196E+001, 7.17749824E-001, -5.80961147E-001
295, 1.34364302E+001, 7.28610577E-001, -5.68196060E-001
296, 1.34453616E+001, 7.39454941E-001, -5.55501204E-001
297, 1.34544134E+001, 7.50282316E-001, -5.42877282E-001
298, 1.34635849E+001, 7.61092105E-001, -5.30324991E-001
299, 1.34728759E+001, 7.71883711E-001, -5.17845023E-001
300, 1.34822856E+001, 7.82656537E-001, -5.05438068E-001
301, 1.34918137E+001, 7.93409990E-001, -4.93104811E-001
302, 1.35014595E+001, 8.04143474E-001, -4.80845934E-001
303, 1.35112225E+001, 8.14856396E-001, -4.68662114E-001
304, 1.35211023E+001, 8.25548166E-001, -4.56554023E-001
305, 1.35310982E+001, 8.36218193E-001, -4.44522330E-001
306, 1.35412097E+001, 8.46865887E-001, -4.32567700E-001
307, 1.35514363E+001, 8.57490661E-001, -4.20690793E-001
308, 1.35617774E+001, 8.68091927E-001, -4.08892265E-001
309, 1.35722323E+001, 8.78669100E-001, -3.97172768E-001
310, 1.35828006E+001, 8.89221596E-001, -3.85532948E-001
311, 1.35934817E+001, 8.99748831E-001, -3.73973450E-001
312, 1.36042749E+001, 9.10250225E-001, -3.62494911E-001
313, 1.36151797E+001, 9.20725198E-001, -3.51097965E-001
314, 1.32867425E+001, 5.64024197E-001, -7.45401026E-001
315, 1.32793177E+001, 5.52926661E-001, -7.59412910E-001
316, 1.32719480E+001, 5.41899199E-001, -7.73508964E-001
317, 1.32646338E+001, 5.30942252E-001, -7.87688622E-001
318, 1.32573753E+001, 5.20056260E-001, -8.01951315E-001
319, 1.32501727E+001, 5.09241660E-001, -8.16296471E-001
320, 1.32430265E+001, 4.98498886E-001, -8.30723513E-001
321, 1.32359368E+001, 4.87828369E-001, -8.45231864E-001
322, 1.32289040E+001, 4.77230538E-001, -8.59820940E-001
323, 1.32219284E+001, 4.66705816E-001, -8.74490157E-001
324, 1.32150101E+001, 4.56254628E-001, -8.89238925E-001
325, 1.32081496E+001, 4.45877392E-001, -9.04066654E-001
326, 1.32013470E+001, 4.35574525E-001, -9.18972747E-001
327, 1.31946027E+001, 4.25346439E-001, -9.33956606E-001
328, 1.31879169E+001, 4.15193547E-001, -9.49017631E-001
329, 1.31812899E+001, 4.05116254E-001, -9.64155218E-001
330, 1.31747220E+001, 3.95114966E-001, -9.79368757E-001
331, 1.31682133E+001, 3.85190083E-001, -9.94657640E-001
332, 1.31617643E+001, 3.75342005E-001, -1.01002125E+000
333, 1.31553751E+001, 3.65571126E-001, -1.02545898E+000
334, 1.32966649E+001, 5.80388814E-001, -7.34302546E-001
335, 1.31476057E+001, 3.31381772E-001, -1.03380777E+000
336, 1.31461655E+001, 3.06885707E-001, -1.02664534E+000
337, 1.31384340E+001, 2.72669026E-001, -1.03485581E+000
338, 1.31321653E+001, 2.63069178E-001, -1.05031360E+000
339, 1.31259195E+001, 2.53590676E-001, -1.06585535E+000
340, 1.31196972E+001, 2.44234091E-001, -1.08148013E+000
341, 1.31134985E+001, 2.34999986E-001, -1.09718699E+000
342, 1.31073240E+001, 2.25888918E-001, -1.11297499E+000
343, 1.31011740E+001, 2.16901434E-001, -1.12884318E+000
344, 1.30950488E+001, 2.08038077E-001, -1.14479060E+000
345, 1.30889489E+001, 1.99299379E-001, -1.16081630E+000
346, 1.30828745E+001, 1.90685867E-001, -1.17691930E+000
347, 1.30787385E+001, 1.65095152E-001, -1.20785304E+000
348, 1.30728495E+001, 1.57031632E-001, -1.22437388E+000
349, 1.30669970E+001, 1.49303239E-001, -1.24106695E+000
350, 1.30611831E+001, 1.41912944E-001, -1.25792582E+000
351, 1.30554102E+001, 1.34863591E-001, -1.27494401E+000
352, 1.30496804E+001, 1.28157890E-001, -1.29211498E+000
353, 1.30439960E+001, 1.21798419E-001, -1.30943212E+000
354, 1.30383591E+001, 1.15787624E-001, -1.32688879E+000
355, 1.30327719E+001, 1.10127817E-001, -1.34447825E+000
356, 1.30272366E+001, 1.04821174E-001, -1.36219375E+000
357, 1.30787950E+001, 1.76160632E-001, -1.19192070E+000
358, 1.30354765E+001, 9.93721578E-002, -1.38012195E+000
359, 1.30437011E+001, 9.40844799E-002, -1.39806974E+000
360, 1.30382218E+001, 8.96224345E-002, -1.41601417E+000
361, 1.30327616E+001, 8.54898357E-002, -1.43404312E+000
362, 1.30273222E+001, 8.16879730E-002, -1.45215096E+000
363, 1.30219053E+001, 7.82180324E-002, -1.47033205E+000
364, 1.30165126E+001, 7.50810967E-002, -1.48858072E+000
365, 1.30111458E+001, 7.22781446E-002, -1.50689127E+000
366, 1.30058066E+001, 6.98100505E-002, -1.52525798E+000
367, 1.30004965E+001, 6.76775845E-002, -1.54367514E+000
368, 1.29952174E+001, 6.58814120E-002, -1.56213698E+000
369, 1.29763846E+001, 6.47159571E-002, -1.58063782E+000
370, 1.29538950E+001, 6.69043545E-002, -1.59121092E+000
371, 1.36348160E+001, 9.39202590E-001, -3.31210624E-001
372, 1.36434366E+001, 9.47232009E-001, -3.22638007E-001
373, 1.36353431E+001, 9.54464850E-001, -3.12421352E-001
374, 1.36101980E+001, 9.45635809E-001, -3.19326705E-001
375, 1.36017668E+001, 9.37603346E-001, -3.27876095E-001
376, 1.35877419E+001, 9.28238080E-001, -3.33942195E-001
377, 1.35754234E+001, 9.14512960E-001, -3.40118200E-001
378, 1.35646185E+001, 9.03855913E-001, -3.51637157E-001
379, 1.35539241E+001, 8.93174070E-001, -3.63236014E-001
380, 1.35433408E+001, 8.82467997E-001, -3.74914160E-001
381, 1.35328692E+001, 8.71738260E-001, -3.86670975E-001
382, 1.35225098E+001, 8.60985428E-001, -3.98505836E-001
383, 1.35122632E+001, 8.50210070E-001, -4.10418119E-001
384, 1.35021298E+001, 8.39412756E-001, -4.22407191E-001
385, 1.34921103E+001, 8.28594057E-001, -4.34472418E-001
386, 1.34822052E+001, 8.17754546E-001, -4.46613163E-001
387, 1.34724149E+001, 8.06894797E-001, -4.58828781E-001
388, 1.34627401E+001, 7.96015386E-001, -4.71118627E-001
389, 1.34531812E+001, 7.85116887E-001, -4.83482049E-001
390, 1.34437387E+001, 7.74199878E-001, -4.95918394E-001
391, 1.34344131E+001, 7.63264936E-001, -5.08427003E-001
392, 1.34252050E+001, 7.52312641E-001, -5.21007214E-001
393, 1.34161147E+001, 7.41343572E-001, -5.33658361E-001
394, 1.34071429E+001, 7.30358309E-001, -5.46379774E-001
395, 1.33982899E+001, 7.19357435E-001, -5.59170781E-001
396, 1.33895562E+001, 7.08341532E-001, -5.72030703E-001
397, 1.33809423E+001, 6.97311182E-001, -5.84958860E-001
398, 1.33724487E+001, 6.86266970E-001, -5.97954568E-001
399, 1.33640758E+001, 6.75209481E-001, -6.11017138E-001
400, 1.33558240E+001, 6.64139298E-001, -6.24145880E-001
401, 1.33476938E+001, 6.53057010E-001, -6.37340099E-001
402, 1.33396857E+001, 6.41963201E-001, -6.50599096E-001
403, 1.33317999E+001, 6.30858460E-001, -6.63922168E-001
404, 1.33240370E+001, 6.19743375E-001, -6.77308612E-001
405, 1.33163974E+001, 6.08618533E-001, -6.90757718E-001
406, 1.33088814E+001, 5.97484523E-001, -7.04268774E-001
407, 1.33014895E+001, 5.86341936E-001, -7.17841065E-001
408, 1.32939181E+001, 5.57151598E-001, -7.22101225E-001
409, 1.32936140E+001, 5.39111837E-001, -7.12728578E-001
410, 1.32857058E+001, 5.08846341E-001, -7.17471910E-001
411, 1.32781523E+001, 4.96703115E-001, -7.31685992E-001
412, 1.32706499E+001, 4.84642966E-001, -7.45997514E-001
413, 1.32631988E+001, 4.72666456E-001, -7.60405805E-001
414, 1.32557996E+001, 4.60774147E-001, -7.74910193E-001
415, 1.32484524E+001, 4.48966594E-001, -7.89509999E-001
416, 1.32411577E+001, 4.37244348E-001, -8.04204541E-001
417, 1.32339158E+001, 4.25607958E-001, -8.18993132E-001
418, 1.32267270E+001, 4.14057967E-001, -8.33875082E-001
419, 1.32195917E+001, 4.02594916E-001, -8.48849693E-001
420, 1.32125101E+001, 3.91219340E-001, -8.63916267E-001
421, 1.32054827E+001, 3.79931771E-001, -8.79074098E-001
422, 1.31985098E+001, 3.68732737E-001, -8.94322480E-001
423, 1.31915916E+001, 3.57622760E-001, -9.09660698E-001
424, 1.31847286E+001, 3.46602361E-001, -9.25088036E-001
425, 1.31779210E+001, 3.35672055E-001, -9.40603773E-001
426, 1.31711691E+001, 3.24832351E-001, -9.56207183E-001
427, 1.31644733E+001, 3.14083758E-001, -9.71897537E-001
428, 1.31578338E+001, 3.03426778E-001, -9.87674103E-001
429, 1.31512511E+001, 2.92861907E-001, -1.00353614E+000
430, 1.31465434E+001, 2.64305429E-001, -1.03277039E+000
431, 1.31402563E+001, 2.54658285E-001, -1.04827355E+000
432, 1.31339902E+001, 2.45135310E-001, -1.06386172E+000
433, 1.31277455E+001, 2.35737094E-001, -1.07953395E+000
434, 1.31215224E+001, 2.26464218E-001, -1.09528925E+000
435, 1.31153215E+001, 2.17317256E-001, -1.11112665E+000
436, 1.31091431E+001, 2.08296774E-001, -1.12704519E+000
437, 1.31029875E+001, 1.99403331E-001, -1.14304386E+000
438, 1.30968551E+001, 1.90637476E-001, -1.15912168E+000
439, 1.30907464E+001, 1.81999754E-001, -1.17527765E+000
440, 1.31468941E+001, 2.76527083E-001, -1.01785052E+000
441, 1.30983930E+001, 1.73049282E-001, -1.19172236E+000
442, 1.31061830E+001, 1.64091722E-001, -1.20819542E+000
443, 1.31002783E+001, 1.55928420E-001, -1.22464999E+000
444, 1.30944126E+001, 1.48121536E-001, -1.24129045E+000
445, 1.30885885E+001, 1.40674492E-001, -1.25810951E+000
446, 1.30828087E+001, 1.33590551E-001, -1.27509979E+000
447, 1.30770756E+001, 1.26872816E-001, -1.29225385E+000
448, 1.30713916E+001, 1.20524232E-001, -1.30956417E+000
449, 1.30657595E+001, 1.14547579E-001, -1.32702317E+000
450, 1.30601815E+001, 1.08945478E-001, -1.34462320E+000
451, 1.30546601E+001, 1.03720381E-001, -1.36235654E+000
452, 1.36129490E+001, 9.52336165E-001, -3.08419141E-001
453, 1.36030961E+001, 9.41244287E-001, -3.11634111E-001
454, 1.35947172E+001, 9.33194467E-001, -3.20156933E-001
455, 1.35884466E+001, 9.20234305E-001, -3.20188129E-001
456, 1.35905550E+001, 9.15323964E-001, -3.11696503E-001
457, 1.35813802E+001, 8.98435846E-001, -3.14303161E-001
458, 1.35702151E+001, 8.86438511E-001, -3.25499399E-001
459, 1.35591688E+001, 8.74422345E-001, -3.36792910E-001
460, 1.35482421E+001, 8.62388080E-001, -3.48183007E-001
461, 1.35374356E+001, 8.50336446E-001, -3.59668998E-001
462, 1.35267499E+001, 8.38268177E-001, -3.71250185E-001
463, 1.35161857E+001, 8.26184005E-001, -3.82925864E-001
464, 1.35057436E+001, 8.14084665E-001, -3.94695327E-001
465, 1.34954243E+001, 8.01970892E-001, -4.06557856E-001
466, 1.34852284E+001, 7.89843423E-001, -4.18512733E-001
467, 1.34751565E+001, 7.77702994E-001, -4.30559229E-001
468, 1.34652093E+001, 7.65550343E-001, -4.42696613E-001
469, 1.34553872E+001, 7.53386209E-001, -4.54924147E-001
470, 1.34456910E+001, 7.41211332E-001, -4.67241089E-001
471, 1.34361212E+001, 7.29026450E-001, -4.79646689E-001
472, 1.34266784E+001, 7.16832305E-001, -4.92140193E-001
473, 1.34173632E+001, 7.04629638E-001, -5.04720844E-001
474, 1.34081762E+001, 6.92419189E-001, -5.17387874E-001
475, 1.33991178E+001, 6.80201703E-001, -5.30140516E-001
476, 1.33901887E+001, 6.67977919E-001, -5.42977994E-001
477, 1.33813893E+001, 6.55748583E-001, -5.55899528E-001
478, 1.33727203E+001, 6.43514436E-001, -5.68904332E-001
479, 1.33641821E+001, 6.31276223E-001, -5.81991616E-001
480, 1.33557753E+001, 6.19034687E-001, -5.95160585E-001
481, 1.33475004E+001, 6.06790573E-001, -6.08410438E-001
482, 1.33393579E+001, 5.94544623E-001, -6.21740371E-001
483, 1.33313483E+001, 5.82297583E-001, -6.35149573E-001
484, 1.33234720E+001, 5.70050197E-001, -6.48637229E-001
485, 1.33157296E+001, 5.57803209E-001, -6.62202519E-001
486, 1.33081215E+001, 5.45557363E-001, -6.75844620E-001
487, 1.33006481E+001, 5.33313404E-001, -6.89562701E-001
488, 1.32942521E+001, 5.01300372E-001, -7.14155249E-001
489, 1.32867059E+001, 4.89081394E-001, -7.28413283E-001
490, 1.32792078E+001, 4.76949316E-001, -7.42770511E-001
491, 1.32717580E+001, 4.64904721E-001, -7.57226243E-001
492, 1.32643569E+001, 4.52948189E-001, -7.71779783E-001
493, 1.32570050E+001, 4.41080294E-001, -7.86430432E-001
494, 1.32497024E+001, 4.29301608E-001, -8.01177484E-001
495, 1.32424497E+001, 4.17612697E-001, -8.16020231E-001
496, 1.32352471E+001, 4.06014123E-001, -8.30957959E-001
497, 1.32280950E+001, 3.94506443E-001, -8.45989948E-001
498, 1.32209938E+001, 3.83090213E-001, -8.61115478E-001
499, 1.32139437E+001, 3.71765979E-001, -8.76333819E-001
500, 1.32069451E+001, 3.60534288E-001, -8.91644240E-001
501, 1.31999984E+001, 3.49395678E-001, -9.07046004E-001
502, 1.31931039E+001, 3.38350687E-001, -9.22538372E-001
503, 1.31862618E+001, 3.27399845E-001, -9.38120597E-001
504, 1.31794727E+001, 3.16543679E-001, -9.53791930E-001
505, 1.31727367E+001, 3.05782710E-001, -9.69551619E-001
506, 1.31660542E+001, 2.95117457E-001, -9.85398903E-001
507, 1.31594255E+001, 2.84548433E-001, -1.00133302E+000
508, 1.32958150E+001, 5.15751685E-001, -7.00724417E-001
509, 1.31666226E+001, 2.73995102E-001, -1.01788371E+000
510, 1.31740686E+001, 2.64105788E-001, -1.03378206E+000
511, 1.31677657E+001, 2.54415601E-001, -1.04923397E+000
512, 1.31614860E+001, 2.44844059E-001, -1.06476902E+000
513, 1.31552297E+001, 2.35391714E-001, -1.08038632E+000
514, 1.31489973E+001, 2.26059114E-001, -1.09608496E+000
515, 1.31427892E+001, 2.16846798E-001, -1.11186404E+000
516, 1.31366056E+001, 2.07755298E-001, -1.12772265E+000
517, 1.31304470E+001, 1.98785140E-001, -1.14365986E+000
518, 1.31243136E+001, 1.89936842E-001, -1.15967477E+000
519, 1.31182059E+001, 1.81210916E-001, -1.17576644E+000
520, 1.36133134E+001, 9.44837406E-001, -2.95399473E-001
521, 1.36151517E+001, 9.40380706E-001, -2.87687657E-001
522, 1.36088811E+001, 9.27420544E-001, -2.87718853E-001
523, 1.36007723E+001, 9.18917084E-001, -2.95461865E-001
524, 1.35970313E+001, 9.07306107E-001, -2.97824815E-001
525, 1.35929054E+001, 8.94087660E-001, -3.07209236E-001
526, 1.35816123E+001, 8.81993260E-001, -3.18501206E-001
527, 1.35704399E+001, 8.69879621E-001, -3.29892278E-001
528, 1.35593891E+001, 8.57747492E-001, -3.41381747E-001
529, 1.35484604E+001, 8.45597620E-001, -3.52968906E-001
530, 1.35376546E+001, 8.33430758E-001, -3.64653036E-001
531, 1.35269723E+001, 8.21247655E-001, -3.76433419E-001
532, 1.35164142E+001, 8.09049065E-001, -3.88309325E-001
533, 1.35059808E+001, 7.96835740E-001, -4.00280022E-001
534, 1.34956730E+001, 7.84608436E-001, -4.12344770E-001
535, 1.34854912E+001, 7.72367906E-001, -4.24502824E-001
536, 1.34754361E+001, 7.60114906E-001, -4.36753434E-001
537, 1.34655085E+001, 7.47850194E-001, -4.49095844E-001
538, 1.34557087E+001, 7.35574527E-001, -4.61529290E-001
539, 1.34460376E+001, 7.23288663E-001, -4.74053005E-001
540, 1.34364956E+001, 7.10993360E-001, -4.86666215E-001
541, 1.34270833E+001, 6.98689378E-001, -4.99368143E-001
542, 1.34178014E+001, 6.86377476E-001, -5.12158003E-001
543, 1.34086504E+001, 6.74058415E-001, -5.25035006E-001
544, 1.33996309E+001, 6.61732956E-001, -5.37998357E-001
545, 1.33907434E+001, 6.49401859E-001, -5.51047254E-001
546, 1.33819885E+001, 6.37065886E-001, -5.64180893E-001
547, 1.33733667E+001, 6.24725800E-001, -5.77398461E-001
548, 1.33648785E+001, 6.12382361E-001, -5.90699144E-001
549, 1.33565245E+001, 6.00036332E-001, -6.04082120E-001
550, 1.33483053E+001, 5.87688475E-001, -6.17546561E-001
551, 1.33402212E+001, 5.75339554E-001, -6.31091638E-001
552, 1.33322728E+001, 5.62990330E-001, -6.44716513E-001
553, 1.33244606E+001, 5.50641567E-001, -6.58420344E-001
554, 1.33167851E+001, 5.38294026E-001, -6.72202287E-001
555, 1.33092467E+001, 5.25948470E-001, -6.86061489E-001
556, 1.33159080E+001, 5.13686570E-001, -7.00820147E-001
557, 1.33223158E+001, 5.01495210E-001, -7.15792951E-001
558, 1.33147126E+001, 4.89304571E-001, -7.30040433E-001
559, 1.33071607E+001, 4.77196123E-001, -7.44384990E-001
560, 1.32996605E+001, 4.65170420E-001, -7.58825962E-001
561, 1.32922124E+001, 4.53228016E-001, -7.73362686E-001
562, 1.32848167E+001, 4.41369459E-001, -7.87994493E-001
563, 1.32774738E+001, 4.29595295E-001, -8.02720711E-001
564, 1.32701839E+001, 4.17906065E-001, -8.17540664E-001
565, 1.32629474E+001, 4.06302306E-001, -8.32453669E-001
566, 1.32557647E+001, 3.94784551E-001, -8.47459042E-001
567, 1.32486360E+001, 3.83353330E-001, -8.62556094E-001
568, 1.32415617E+001, 3.72009168E-001, -8.77744129E-001
569, 1.32345422E+001, 3.60752587E-001, -8.93022451E-001
570, 1.32275777E+001, 3.49584103E-001, -9.08390356E-001
571, 1.32206686E+001, 3.38504231E-001, -9.23847139E-001
572, 1.32138152E+001, 3.27513478E-001, -9.39392089E-001
573, 1.32070177E+001, 3.16612352E-001, -9.55024492E-001
574, 1.32002766E+001, 3.05801352E-001, -9.70743629E-001
575, 1.31935921E+001, 2.95080975E-001, -9.86548777E-001
576, 1.31869646E+001, 2.84451715E-001, -1.00243921E+000
577, 1.36214353E+001, 9.32777899E-001, -2.74639842E-001
578, 1.36206103E+001, 9.23173684E-001, -2.80549234E-001
579, 1.36124644E+001, 9.14667879E-001, -2.88283149E-001
580, 1.36204802E+001, 9.06112319E-001, -2.96174078E-001
581, 1.36250593E+001, 8.94041126E-001, -3.07558821E-001
582, 1.36135989E+001, 8.81996656E-001, -3.18886936E-001
583, 1.36022617E+001, 8.69929915E-001, -3.30314722E-001
584, 1.35910481E+001, 8.57841664E-001, -3.41841456E-001
585, 1.35799591E+001, 8.45732668E-001, -3.53466410E-001
586, 1.35689952E+001, 8.33603691E-001, -3.65188849E-001
587, 1.35581571E+001, 8.21455500E-001, -3.77008033E-001
588, 1.35474456E+001, 8.09288863E-001, -3.88923216E-001
589, 1.35368614E+001, 7.97104547E-001, -4.00933644E-001
590, 1.35264050E+001, 7.84903323E-001, -4.13038559E-001
591, 1.35160772E+001, 7.72685961E-001, -4.25237196E-001
592, 1.35058785E+001, 7.60453233E-001, -4.37528784E-001
593, 1.34958098E+001, 7.48205913E-001, -4.49912548E-001
594, 1.34858715E+001, 7.35944773E-001, -4.62387703E-001
595, 1.34760643E+001, 7.23670589E-001, -4.74953463E-001
596, 1.34663888E+001, 7.11384136E-001, -4.87609033E-001
597, 1.34568457E+001, 6.99086190E-001, -5.00353615E-001
598, 1.34474356E+001, 6.86777528E-001, -5.13186402E-001
599, 1.34381590E+001, 6.74458928E-001, -5.26106584E-001
600, 1.34290165E+001, 6.62131167E-001, -5.39113345E-001
601, 1.34200087E+001, 6.49795025E-001, -5.52205863E-001
602, 1.34111362E+001, 6.37451282E-001, -5.65383311E-001
603, 1.34023995E+001, 6.25100716E-001, -5.78644856E-001
604, 1.33937992E+001, 6.12744108E-001, -5.91989661E-001
605, 1.33853358E+001, 6.00382240E-001, -6.05416883E-001
606, 1.33770099E+001, 5.88015891E-001, -6.18925672E-001
607, 1.33688220E+001, 5.75645843E-001, -6.32515177E-001
608, 1.33607726E+001, 5.63272878E-001, -6.46184538E-001
609, 1.33528622E+001, 5.50897777E-001, -6.59932892E-001
610, 1.33450913E+001, 5.38521321E-001, -6.73759369E-001
611, 1.33374604E+001, 5.26144294E-001, -6.87663098E-001
612, 1.36451296E+001, 9.31625520E-001, -2.72951365E-001
613, 1.36532160E+001, 9.23068554E-001, -2.80835304E-001
614, 1.36449289E+001, 9.14565559E-001, -2.88583198E-001
615, 1.30354490E+001, 2.02652034E-001, -1.40786567E+000
616, 1.30295201E+001, 1.99224648E-001, -1.42492356E+000
617, 1.30236309E+001, 1.95965030E-001, -1.44202784E+000
618, 1.30177751E+001, 1.92956236E-001, -1.45919040E+000
619, 1.30119496E+001, 1.90243230E-001, -1.47641307E+000
620, 1.30061561E+001, 1.87811649E-001, -1.49368793E+000
621, 1.30003972E+001, 1.85641920E-001, -1.51100811E+000
622, 1.29946764E+001, 1.83712407E-001, -1.52836816E+000
623, 1.29889995E+001, 1.81976646E-001, -1.54576306E+000
624, 1.29833740E+001, 1.80372253E-001, -1.56318805E+000
625, 1.31010206E+001, 2.65193133E-001, -1.22766015E+000
626, 1.30951837E+001, 2.57840911E-001, -1.24345991E+000
627, 1.30893260E+001, 2.50672618E-001, -1.25933393E+000
628, 1.30834395E+001, 2.43780175E-001, -1.27531885E+000
629, 1.30775200E+001, 2.37236201E-001, -1.29144051E+000
630, 1.30715677E+001, 2.31082596E-001, -1.30770663E+000
631, 1.30655825E+001, 2.25359460E-001, -1.32411915E+000
632, 1.30595652E+001, 2.20098694E-001, -1.34067252E+000
633, 1.30535238E+001, 2.15233496E-001, -1.35733514E+000
634, 1.30474716E+001, 2.10632464E-001, -1.37406894E+000
635, 1.30151077E+001, 1.98480265E-001, -1.40731106E+000
636, 1.30090968E+001, 1.94918503E-001, -1.42441689E+000
637, 1.30031862E+001, 1.91615280E-001, -1.44157411E+000
638, 1.29973344E+001, 1.88563792E-001, -1.45878920E+000
639, 1.29915265E+001, 1.85783868E-001, -1.47606108E+000
640, 1.29857608E+001, 1.83288846E-001, -1.49338906E+000
641, 1.29800421E+001, 1.81073022E-001, -1.51076846E+000
642, 1.29743795E+001, 1.79110880E-001, -1.52819058E+000
643, 1.29687880E+001, 1.77372766E-001, -1.54564544E+000
644, 1.29632940E+001, 1.75856011E-001, -1.56312614E+000
645, 1.29689185E+001, 1.77261355E-001, -1.60879612E+000
646, 1.29733641E+001, 1.78019902E-001, -1.59471068E+000
647, 1.31656478E+001, 3.57034022E-001, -1.05964472E+000
648, 1.31596157E+001, 3.48102666E-001, -1.07453216E+000
649, 1.31536226E+001, 3.39235980E-001, -1.08947360E+000
650, 1.31476640E+001, 3.30467656E-001, -1.10448674E+000
651, 1.31417369E+001, 3.21822176E-001, -1.11958379E+000
652, 1.31358403E+001, 3.13309650E-001, -1.13476843E+000
653, 1.31299735E+001, 3.04939100E-001, -1.15004346E+000
654, 1.31241369E+001, 2.96717216E-001, -1.16541016E+000
655, 1.31183336E+001, 2.88621205E-001, -1.18085584E+000
656, 1.31125689E+001, 2.80608708E-001, -1.19635950E+000
657, 1.30807855E+001, 2.61082155E-001, -1.22646554E+000
658, 1.30748871E+001, 2.53708755E-001, -1.24233866E+000
659, 1.30689980E+001, 2.46562423E-001, -1.25829245E+000
660, 1.30630782E+001, 2.39711215E-001, -1.27435204E+000
661, 1.30571052E+001, 2.33205513E-001, -1.29053438E+000
662, 1.30510899E+001, 2.27075342E-001, -1.30684457E+000
663, 1.30450496E+001, 2.21352528E-001, -1.32329016E+000
664, 1.30390144E+001, 2.16074056E-001, -1.33987798E+000
665, 1.30330154E+001, 2.11199189E-001, -1.35659044E+000
666, 1.30270909E+001, 2.06645735E-001, -1.37339410E+000
667, 1.29590818E+001, 1.48060791E-001, -1.56818116E+000
668, 1.30112321E+001, 1.77504665E-001, -1.40769808E+000
669, 1.29696989E+001, 1.55992933E-001, -1.53443592E+000
670, 1.29807777E+001, 1.61644628E-001, -1.49986262E+000
671, 1.29923852E+001, 1.65694593E-001, -1.46402660E+000
672, 1.29998924E+001, 1.13657222E-001, -1.42954158E+000
673, 1.29593082E+001, 1.07800967E-001, -1.56516523E+000
674, 1.29727046E+001, 9.67082078E-002, -1.51844324E+000
675, 1.29834864E+001, 1.02317425E-001, -1.48254930E+000
676, 1.30058415E+001, 1.70925898E-001, -1.42306441E+000
677, 1.29995926E+001, 1.66244897E-001, -1.44162318E+000
678, 1.29953813E+001, 1.49769972E-001, -1.45173071E+000
679, 1.30028947E+001, 1.52924156E-001, -1.42845346E+000
680, 1.29892977E+001, 1.48413641E-001, -1.47086694E+000
681, 1.29917939E+001, 1.33108124E-001, -1.46019200E+000
682, 1.29863215E+001, 1.33309767E-001, -1.47800610E+000
683, 1.29984954E+001, 1.33608414E-001, -1.43852300E+000
684, 1.30042706E+001, 1.35381881E-001, -1.42002301E+000
685, 1.29586219E+001, 1.60012666E-001, -1.57031934E+000
686, 1.29579627E+001, 9.18244026E-002, -1.56893036E+000
687, 1.29631591E+001, 9.41979640E-002, -1.55106557E+000
688, 1.29644523E+001, 1.15607544E-001, -1.54820300E+000
689, 1.29601509E+001, 1.28649200E-001, -1.56353262E+000
690, 1.29659141E+001, 1.32588045E-001, -1.54465638E+000
691, 1.29695193E+001, 1.21501831E-001, -1.53170036E+000
692, 1.29886771E+001, 1.15952687E-001, -1.46739216E+000
693, 1.29947728E+001, 1.17998851E-001, -1.44755532E+000
694, 1.30090020E+001, 1.59939797E-001, -1.41051912E+000
695, 1.29711167E+001, 1.41100093E-001, -1.52837540E+000
696, 1.29749473E+001, 1.28310602E-001, -1.51447250E+000
697, 1.29768603E+001, 1.44409894E-001, -1.51016292E+000
698, 1.29803267E+001, 1.30330840E-001, -1.49710963E+000
699, 1.29783664E+001, 1.10762802E-001, -1.50098309E+000
700, 1.29637770E+001, 1.55760581E-001, -1.55346080E+000
701, 1.29865415E+001, 1.63566891E-001, -1.48199021E+000
702, 1.30055568E+001, 1.18018069E-001, -1.41148954E+000
703, 1.29837320E+001, 1.46877975E-001, -1.48841950E+000
704, 1.29678483E+001, 1.03673902E-001, -1.53570069E+000
705, 1.30104907E+001, 1.20136319E-001, -1.39530392E+000
706, 1.30100222E+001, 1.39631214E-001, -1.40208680E+000
707, 1.29750456E+001, 1.59084206E-001, -1.51769833E+000
708, 1.29780963E+001, 9.63647216E-002, -1.50000444E+000
709, 1.29830328E+001, 1.17881901E-001, -1.48643115E+000
710, 1.29627236E+001, 1.41699858E-001, -1.55586492E+000
711, 1.29728912E+001, 1.11775720E-001, -1.51943936E+000
712, 1.29890686E+001, 1.02300099E-001, -1.46366491E+000
713, 1.29674334E+001, 8.89568621E-002, -1.53585234E+000
714, 1.29944419E+001, 1.03645869E-001, -1.44574189E+000
715, 1.29667399E+001, 1.45241582E-001, -1.54301012E+000
716, 1.29533263E+001, 1.73616986E-001, -1.59502796E+000
717, 1.29487978E+001, 1.72841492E-001, -1.60941239E+000
718, 1.31780302E+001, 3.75773142E-001, -1.02945527E+000
719, 1.31844049E+001, 3.85562254E-001, -1.01415278E+000
720, 1.31908476E+001, 3.95380438E-001, -9.98897574E-001
721, 1.31973556E+001, 4.05244556E-001, -9.83699871E-001
722, 1.32039260E+001, 4.15171311E-001, -9.68569736E-001
723, 1.32105559E+001, 4.25177181E-001, -9.53517317E-001
724, 1.32172420E+001, 4.35278330E-001, -9.38553048E-001
725, 1.32239820E+001, 4.45486540E-001, -9.23685573E-001
726, 1.32307756E+001, 4.55797581E-001, -9.08914077E-001
727, 1.32376239E+001, 4.66203532E-001, -8.94235193E-001
728, 1.32445277E+001, 4.76696637E-001, -8.79645327E-001
729, 1.32514880E+001, 4.87269308E-001, -8.65140696E-001
730, 1.32585059E+001, 4.97914084E-001, -8.50717399E-001
731, 1.32655825E+001, 5.08623653E-001, -8.36371321E-001
732, 1.32727197E+001, 5.19390320E-001, -8.22098439E-001
733, 1.32799181E+001, 5.30205235E-001, -8.07892828E-001
734, 1.32871793E+001, 5.41059034E-001, -7.93748685E-001
735, 1.32945049E+001, 5.51942334E-001, -7.79660100E-001
736, 1.33018963E+001, 5.62845683E-001, -7.65621229E-001
737, 1.33093549E+001, 5.73759574E-001, -7.51626274E-001
738, 1.30923802E+001, 2.76392373E-001, -1.19499808E+000
739, 1.30981163E+001, 2.84320036E-001, -1.17941615E+000
740, 1.31039071E+001, 2.92375411E-001, -1.16389987E+000
741, 1.31097380E+001, 3.00560537E-001, -1.14845525E+000
742, 1.31156027E+001, 3.08884804E-001, -1.13309521E+000
743, 1.31215014E+001, 3.17353410E-001, -1.11782711E+000
744, 1.31274365E+001, 3.25961648E-001, -1.10265103E+000
745, 1.31334114E+001, 3.34694883E-001, -1.08755975E+000
746, 1.31394312E+001, 3.43535426E-001, -1.07254490E+000
747, 1.31455084E+001, 3.52482474E-001, -1.05759917E+000
748, 1.30757123E+001, 2.28047960E-001, -1.22002362E+000
749, 1.30698549E+001, 2.20466416E-001, -1.23617378E+000
750, 1.30640202E+001, 2.13274630E-001, -1.25234834E+000
751, 1.30581316E+001, 2.06396833E-001, -1.26870327E+000
752, 1.30522008E+001, 1.99829579E-001, -1.28520619E+000
753, 1.30462666E+001, 1.93597011E-001, -1.30180756E+000
754, 1.30403311E+001, 1.87686466E-001, -1.31855330E+000
755, 1.30344332E+001, 1.82115499E-001, -1.33539297E+000
756, 1.30286064E+001, 1.76873228E-001, -1.35229929E+000
757, 1.30227861E+001, 1.71901023E-001, -1.36944284E+000
758, 1.30732957E+001, 2.00904740E-001, -1.21473138E+000
759, 1.30674056E+001, 1.93064236E-001, -1.23106537E+000
760, 1.30615662E+001, 1.85619683E-001, -1.24743484E+000
761, 1.30557243E+001, 1.78509405E-001, -1.26397463E+000
762, 1.30498729E+001, 1.71701131E-001, -1.28070883E+000
763, 1.30440491E+001, 1.65235602E-001, -1.29755216E+000
764, 1.30382366E+001, 1.59099367E-001, -1.31455522E+000
765, 1.30324715E+001, 1.53320842E-001, -1.33162953E+000
766, 1.30267648E+001, 1.47867274E-001, -1.34880588E+000
767, 1.30210552E+001, 1.42693379E-001, -1.36622721E+000
768, 1.30104515E+001, 9.78319023E-002, -1.39812382E+000
769, 1.30049635E+001, 9.33051510E-002, -1.41605141E+000
770, 1.29994777E+001, 8.90153951E-002, -1.43403766E+000
771, 1.29940144E+001, 8.50612617E-002, -1.45210932E+000
772, 1.29885903E+001, 8.15001071E-002, -1.47027803E+000
773, 1.29832135E+001, 7.83297600E-002, -1.48853007E+000
774, 1.29778858E+001, 7.55463658E-002, -1.50685431E+000
775, 1.29726042E+001, 7.31453647E-002, -1.52523900E+000
776, 1.29673520E+001, 7.10683971E-002, -1.54367181E+000
777, 1.29621074E+001, 6.92189033E-002, -1.56213844E+000
778, 1.29389613E+001, 1.45636859E-001, -1.63532724E+000
779, 1.29424043E+001, 1.45493092E-001, -1.62339794E+000
780, 1.29406668E+001, 1.33484931E-001, -1.62950355E+000
781, 1.29365033E+001, 1.33351124E-001, -1.64393151E+000
782, 1.29444708E+001, 1.33909249E-001, -1.61631896E+000
783, 1.29385154E+001, 1.20482135E-001, -1.63705027E+000
784, 1.29342494E+001, 1.20764116E-001, -1.65183068E+000
785, 1.29508606E+001, 1.09290293E-001, -1.59435149E+000
786, 1.29293865E+001, 9.94186084E-002, -1.66883224E+000
787, 1.29483862E+001, 1.54421700E-001, -1.60260667E+000
788, 1.29290787E+001, 1.43216825E-001, -1.66958900E+000
789, 1.29439121E+001, 9.48478952E-002, -1.61853128E+000
790, 1.29363058E+001, 1.08193724E-001, -1.64479387E+000
791, 1.29491902E+001, 9.43720975E-002, -1.60024507E+000
792, 1.29512312E+001, 1.29589938E-001, -1.59292387E+000
793, 1.29446223E+001, 1.54345746E-001, -1.61564963E+000
794, 1.29429819E+001, 1.20565729E-001, -1.62157248E+000
795, 1.29257085E+001, 1.10579589E-001, -1.68149797E+000
796, 1.29264142E+001, 1.29557221E-001, -1.67891846E+000
797, 1.29407784E+001, 1.07149362E-001, -1.62930311E+000
798, 1.29298118E+001, 1.18824943E-001, -1.66722126E+000
799, 1.29471306E+001, 1.22290896E-001, -1.60718447E+000
800, 1.29338306E+001, 1.44345887E-001, -1.65311504E+000
801, 1.29518861E+001, 1.47725227E-001, -1.59052623E+000
802, 1.29480678E+001, 1.38670084E-001, -1.60382137E+000
803, 1.29522840E+001, 9.39631807E-002, -1.58952755E+000
804, 1.29342102E+001, 9.62183482E-002, -1.65213991E+000
805, 1.29385735E+001, 9.52432931E-002, -1.63702729E+000
806, 1.29316480E+001, 1.31676686E-001, -1.66076766E+000
807, 1.29327927E+001, 1.08683948E-001, -1.65696359E+000
808, 1.29254186E+001, 9.57325588E-002, -1.68260775E+000
809, 1.29251510E+001, 1.45009954E-001, -1.68318634E+000
810, 1.29533217E+001, 7.77929439E-002, -1.58604638E+000
811, 1.29462582E+001, 1.07876024E-001, -1.61030951E+000
812, 1.29518700E+001, 1.58650354E-001, -1.59050488E+000
813, 1.29453017E+001, 1.44083493E-001, -1.61336802E+000
814, 1.29433362E+001, 1.60361708E-001, -1.62006357E+000
815, 1.35988128E+001, 9.19989309E-001, -3.49517450E-001
816, 1.35879661E+001, 9.09558390E-001, -3.60987699E-001
817, 1.35772311E+001, 8.99087422E-001, -3.72526737E-001
818, 1.35666089E+001, 8.88577417E-001, -3.84134608E-001
819, 1.35561002E+001, 8.78029210E-001, -3.95811079E-001
820, 1.35457057E+001, 8.67443425E-001, -4.07555756E-001
821, 1.35354263E+001, 8.56820501E-001, -4.19368041E-001
822, 1.35252627E+001, 8.46160685E-001, -4.31247143E-001
823, 1.35152158E+001, 8.35463937E-001, -4.43192290E-001
824, 1.35052863E+001, 8.24730207E-001, -4.55202255E-001
825, 1.34954751E+001, 8.13959269E-001, -4.67275832E-001
826, 1.34857842E+001, 8.03151935E-001, -4.79414025E-001
827, 1.34762117E+001, 7.92312792E-001, -4.91617286E-001
828, 1.34667580E+001, 7.81445760E-001, -5.03888029E-001
829, 1.34574232E+001, 7.70554958E-001, -5.16228361E-001
830, 1.34482068E+001, 7.59644599E-001, -5.28640290E-001
831, 1.34391087E+001, 7.48718880E-001, -5.41125936E-001
832, 1.34301286E+001, 7.37782065E-001, -5.53687367E-001
833, 1.34212664E+001, 7.26838469E-001, -5.66326655E-001
834, 1.34125217E+001, 7.15892459E-001, -5.79045839E-001
835, 1.34038939E+001, 7.04948465E-001, -5.91846858E-001
836, 1.33953839E+001, 6.94010719E-001, -6.04731711E-001
837, 1.33869911E+001, 6.83079801E-001, -6.17699049E-001
838, 1.33787165E+001, 6.72153724E-001, -6.30746064E-001
839, 1.33705612E+001, 6.61230449E-001, -6.43870054E-001
840, 1.33625259E+001, 6.50307941E-001, -6.57068315E-001
841, 1.33546116E+001, 6.39384156E-001, -6.70338228E-001
842, 1.33468193E+001, 6.28457044E-001, -6.83677203E-001
843, 1.33391499E+001, 6.17524537E-001, -6.97082659E-001
844, 1.33316042E+001, 6.06584559E-001, -7.10552014E-001
845, 1.33241829E+001, 5.95635064E-001, -7.24082523E-001
846, 1.32888060E+001, 5.68845354E-001, -7.49002219E-001
847, 1.32811168E+001, 5.57496651E-001, -7.63456108E-001
848, 1.32735816E+001, 5.46339796E-001, -7.77762080E-001
849, 1.32662026E+001, 5.35372742E-001, -7.91943140E-001
850, 1.32590131E+001, 5.24640865E-001, -8.05950141E-001
851, 1.32520152E+001, 5.14141971E-001, -8.19794896E-001
852, 1.32451212E+001, 5.03740373E-001, -8.33665260E-001
853, 1.32382319E+001, 4.93285741E-001, -8.47766566E-001
854, 1.32313039E+001, 4.82723154E-001, -8.62176452E-001
855, 1.32243865E+001, 4.72143225E-001, -8.76785189E-001
856, 1.32175139E+001, 4.61613509E-001, -8.91516012E-001
857, 1.32107115E+001, 4.51188037E-001, -9.06302882E-001
858, 1.32040087E+001, 4.40926902E-001, -9.21063296E-001
859, 1.31974521E+001, 4.30916151E-001, -9.35679804E-001
860, 1.31910066E+001, 4.21108781E-001, -9.50230211E-001
861, 1.31845832E+001, 4.11363196E-001, -9.64914433E-001
862, 1.31781010E+001, 4.01546934E-001, -9.79913193E-001
863, 1.31715603E+001, 3.91651604E-001, -9.95219011E-001
864, 1.31649855E+001, 3.81706683E-001, -1.01076916E+000
865, 1.31583682E+001, 3.71693592E-001, -1.02657512E+000
866, 1.31414720E+001, 3.22104906E-001, -1.04888037E+000
867, 1.31353508E+001, 3.12947784E-001, -1.06403141E+000
868, 1.31292501E+001, 3.03910971E-001, -1.07926282E+000
869, 1.31231787E+001, 2.94993903E-001, -1.09457625E+000
870, 1.31171431E+001, 2.86196433E-001, -1.10997280E+000
871, 1.31111447E+001, 2.77519005E-001, -1.12545178E+000
872, 1.31051817E+001, 2.68962475E-001, -1.14101156E+000
873, 1.30992499E+001, 2.60528125E-001, -1.15664967E+000
874, 1.30933424E+001, 2.52217359E-001, -1.17236272E+000
875, 1.30874525E+001, 2.44031539E-001, -1.18814780E+000
876, 1.31399544E+001, 2.97387140E-001, -1.04186864E+000
877, 1.31337604E+001, 2.88008467E-001, -1.05717331E+000
878, 1.31275867E+001, 2.78750727E-001, -1.07255971E+000
879, 1.31214382E+001, 2.69613907E-001, -1.08802821E+000
880, 1.31153209E+001, 2.60597978E-001, -1.10357976E+000
881, 1.31092381E+001, 2.51703150E-001, -1.11921441E+000
882, 1.31031884E+001, 2.42930266E-001, -1.13493057E+000
883, 1.30971653E+001, 2.34280821E-001, -1.15072510E+000
884, 1.30911616E+001, 2.25756251E-001, -1.16659448E+000
885, 1.30851736E+001, 2.17357530E-001, -1.18253674E+000
886, 1.30729026E+001, 1.67938387E-001, -1.20833954E+000
887, 1.30670085E+001, 1.59855872E-001, -1.22482800E+000
888, 1.30611372E+001, 1.52027389E-001, -1.24144501E+000
889, 1.30553233E+001, 1.44558439E-001, -1.25824439E+000
890, 1.30495858E+001, 1.37505815E-001, -1.27524920E+000
891, 1.30439162E+001, 1.30856007E-001, -1.29243430E+000
892, 1.30382976E+001, 1.24591568E-001, -1.30977691E+000
893, 1.30327093E+001, 1.18695767E-001, -1.32725531E+000
894, 1.30271301E+001, 1.13108879E-001, -1.34484414E+000
895, 1.30215420E+001, 1.07740779E-001, -1.36251321E+000
896, 1.30299855E+001, 9.47836094E-002, -1.39803769E+000
897, 1.30245068E+001, 9.03039805E-002, -1.41598432E+000
898, 1.30190469E+001, 8.60432190E-002, -1.43398882E+000
899, 1.30136108E+001, 8.21111228E-002, -1.45207620E+000
900, 1.30082021E+001, 7.85752738E-002, -1.47025530E+000
901, 1.30028220E+001, 7.54367695E-002, -1.48851605E+000
902, 1.29974720E+001, 7.26910222E-002, -1.50684765E+000
903, 1.29921535E+001, 7.03286112E-002, -1.52523959E+000
904, 1.29868666E+001, 6.82822098E-002, -1.54367785E+000
905, 1.29816107E+001, 6.64466268E-002, -1.56214849E+000
906, 1.36182563E+001, 9.38395762E-001, -3.29541457E-001
907, 1.36267812E+001, 9.46433410E-001, -3.20985919E-001
908, 1.33042803E+001, 5.91292578E-001, -7.20796096E-001
909, 1.33119391E+001, 6.02195320E-001, -7.07306650E-001
910, 1.33196390E+001, 6.13116518E-001, -6.93850728E-001
911, 1.33273918E+001, 6.24057644E-001, -6.80438850E-001
912, 1.33352072E+001, 6.35018194E-001, -6.67079173E-001
913, 1.33430939E+001, 6.45996318E-001, -6.53778056E-001
914, 1.33510598E+001, 6.56989407E-001, -6.40540594E-001
915, 1.33591121E+001, 6.67994589E-001, -6.27371065E-001
916, 1.33672581E+001, 6.79009145E-001, -6.14273321E-001
917, 1.33755051E+001, 6.90030845E-001, -6.01251129E-001
918, 1.33838608E+001, 7.01058299E-001, -5.88308420E-001
919, 1.33923311E+001, 7.12088784E-001, -5.75446943E-001
920, 1.34009177E+001, 7.23116649E-001, -5.62665025E-001
921, 1.34096232E+001, 7.34136776E-001, -5.49961073E-001
922, 1.34184505E+001, 7.45144441E-001, -5.37333853E-001
923, 1.34274031E+001, 7.56135146E-001, -5.24782391E-001
924, 1.34364847E+001, 7.67104519E-001, -5.12305948E-001
925, 1.34456992E+001, 7.78048258E-001, -4.99904051E-001
926, 1.34550507E+001, 7.88962095E-001, -4.87576602E-001
927, 1.34645437E+001, 7.99841799E-001, -4.75324024E-001
928, 1.34741828E+001, 8.10683190E-001, -4.63147532E-001
929, 1.34839701E+001, 8.21480502E-001, -4.51051540E-001
930, 1.34939012E+001, 8.32236814E-001, -4.39033680E-001
931, 1.35039652E+001, 8.42958754E-001, -4.27090080E-001
932, 1.35141504E+001, 8.53651990E-001, -4.15218731E-001
933, 1.35244452E+001, 8.64322138E-001, -4.03417853E-001
934, 1.35348377E+001, 8.74974599E-001, -3.91685559E-001
935, 1.35453159E+001, 8.85614421E-001, -3.80019453E-001
936, 1.35558675E+001, 8.96246167E-001, -3.68416199E-001
937, 1.35664799E+001, 9.06873746E-001, -3.56870946E-001
938, 1.35771391E+001, 9.17500220E-001, -3.45376473E-001
939, 1.32864041E+001, 5.45502219E-001, -7.36279473E-001
940, 1.32790205E+001, 5.34016273E-001, -7.50244318E-001
941, 1.32715874E+001, 5.22594013E-001, -7.64456289E-001
942, 1.32641963E+001, 5.11279243E-001, -7.78714459E-001
943, 1.32568602E+001, 5.00086903E-001, -7.93024892E-001
944, 1.32495901E+001, 4.89005923E-001, -8.07397057E-001
945, 1.32423744E+001, 4.77986141E-001, -8.21888063E-001
946, 1.32352261E+001, 4.67020839E-001, -8.36494349E-001
947, 1.32281582E+001, 4.56130674E-001, -8.51183489E-001
948, 1.32211664E+001, 4.45318739E-001, -8.65953801E-001
949, 1.32142427E+001, 4.34579351E-001, -8.80814501E-001
950, 1.32073859E+001, 4.23919954E-001, -8.95757514E-001
951, 1.32005858E+001, 4.13336146E-001, -9.10792072E-001
952, 1.31938380E+001, 4.02830075E-001, -9.25915981E-001
953, 1.31871531E+001, 3.92420154E-001, -9.41095538E-001
954, 1.31805258E+001, 3.82101757E-001, -9.56321951E-001
955, 1.31739228E+001, 3.71834922E-001, -9.71644582E-001
956, 1.31673288E+001, 3.61612725E-001, -9.87073338E-001
957, 1.31607471E+001, 3.51457819E-001, -1.00258100E+000
958, 1.31541751E+001, 3.41380988E-001, -1.01815821E+000
959, 1.32859948E+001, 5.27076560E-001, -7.27114485E-001
960, 1.32786317E+001, 5.15285378E-001, -7.40994650E-001
961, 1.32711542E+001, 5.03515130E-001, -7.55285632E-001
962, 1.32637174E+001, 4.91851493E-001, -7.69624737E-001
963, 1.32563247E+001, 4.80302859E-001, -7.84036120E-001
964, 1.32490130E+001, 4.68898376E-001, -7.98479799E-001
965, 1.32417559E+001, 4.57561343E-001, -8.13049700E-001
966, 1.32345637E+001, 4.46279815E-001, -8.27746083E-001
967, 1.32274438E+001, 4.35068166E-001, -8.42540489E-001
968, 1.32204014E+001, 4.23945781E-001, -8.57411413E-001
969, 1.32134251E+001, 4.12898664E-001, -8.72379061E-001
970, 1.32065158E+001, 4.01938004E-001, -8.87430975E-001
971, 1.31996566E+001, 3.91052407E-001, -9.02586779E-001
972, 1.31928519E+001, 3.80258537E-001, -9.17822835E-001
973, 1.31861123E+001, 3.69568008E-001, -9.33111743E-001
974, 1.31794304E+001, 3.58971777E-001, -9.48449974E-001
975, 1.31727549E+001, 3.48406991E-001, -9.63922321E-001
976, 1.31660911E+001, 3.37902760E-001, -9.79490914E-001
977, 1.31594406E+001, 3.27477982E-001, -9.95135715E-001
978, 1.31528010E+001, 3.17140306E-001, -1.01085150E+000
979, 1.31406071E+001, 2.66854880E-001, -1.03331214E+000
980, 1.31343220E+001, 2.57230188E-001, -1.04880511E+000
981, 1.31280484E+001, 2.47694401E-001, -1.06435889E+000
982, 1.31217996E+001, 2.38285374E-001, -1.08000061E+000
983, 1.31155840E+001, 2.29024301E-001, -1.09574462E+000
984, 1.31094020E+001, 2.19909412E-001, -1.11158411E+000
985, 1.31032505E+001, 2.10936919E-001, -1.12751392E+000
986, 1.30971239E+001, 2.02102823E-001, -1.14352916E+000
987, 1.30910125E+001, 1.93385327E-001, -1.15961610E+000
988, 1.30849052E+001, 1.84750285E-001, -1.17575433E+000
989, 1.30948670E+001, 1.64710585E-001, -1.20817050E+000
990, 1.30895789E+001, 1.56565687E-001, -1.22465417E+000
991, 1.30836977E+001, 1.48686456E-001, -1.24125653E+000
992, 1.30776222E+001, 1.41186344E-001, -1.25804428E+000
993, 1.30715086E+001, 1.34131136E-001, -1.27504540E+000
994, 1.30654110E+001, 1.27505290E-001, -1.29223698E+000
995, 1.30593490E+001, 1.21286337E-001, -1.30959433E+000
996, 1.30533266E+001, 1.15448501E-001, -1.32709340E+000
997, 1.30473439E+001, 1.09918938E-001, -1.34470450E+000
998, 1.30413976E+001, 1.04594448E-001, -1.36239303E+000
999, 1.35961514E+001, 9.36197005E-001, -3.25382902E-001
1000, 1.36045112E+001, 9.44265481E-001, -3.16878912E-001
1001, 1.35777084E+001, 9.09087434E-001, -3.31634739E-001
1002, 1.35669386E+001, 8.97804273E-001, -3.43123011E-001
1003, 1.35562006E+001, 8.86509460E-001, -3.54664417E-001
1004, 1.35455267E+001, 8.75271836E-001, -3.66274063E-001
1005, 1.35348884E+001, 8.64015519E-001, -3.77955663E-001
1006, 1.35243093E+001, 8.52760770E-001, -3.89697144E-001
1007, 1.35138280E+001, 8.41550958E-001, -4.01493592E-001
1008, 1.35035733E+001, 8.30501542E-001, -4.13243599E-001
1009, 1.34934240E+001, 8.19433443E-001, -4.25113886E-001
1010, 1.34832538E+001, 8.08165641E-001, -4.37251515E-001
1011, 1.34732745E+001, 7.96918789E-001, -4.49414225E-001
1012, 1.34634939E+001, 7.85693012E-001, -4.61616094E-001
1013, 1.34538569E+001, 7.74424284E-001, -4.73931712E-001
1014, 1.34443669E+001, 7.63123399E-001, -4.86345765E-001
1015, 1.34350199E+001, 7.51793730E-001, -4.98852447E-001
1016, 1.34258211E+001, 7.40447079E-001, -5.11439681E-001
1017, 1.34167643E+001, 7.29080717E-001, -5.24110687E-001
1018, 1.34078421E+001, 7.17692807E-001, -5.36868315E-001
1019, 1.33990576E+001, 7.06294284E-001, -5.49699711E-001
1020, 1.33904105E+001, 6.94886313E-001, -5.62601124E-001
1021, 1.33819061E+001, 6.83478997E-001, -5.75559464E-001
1022, 1.33734874E+001, 6.72011687E-001, -5.88648516E-001
1023, 1.33651367E+001, 6.60484661E-001, -6.01876129E-001
1024, 1.33570133E+001, 6.49121799E-001, -6.14973246E-001
1025, 1.33490094E+001, 6.37759988E-001, -6.28092029E-001
1026, 1.33409959E+001, 6.26233182E-001, -6.41406337E-001
1027, 1.33330295E+001, 6.14667950E-001, -6.54785908E-001
1028, 1.33251101E+001, 6.03099792E-001, -6.68210047E-001
1029, 1.33172479E+001, 5.91567416E-001, -6.81650528E-001
1030, 1.33094406E+001, 5.80079026E-001, -6.95101816E-001
1031, 1.33016671E+001, 5.68609420E-001, -7.08585636E-001
1032, 1.35797313E+001, 9.03843496E-001, -3.23029980E-001
1033, 1.35688312E+001, 8.92079618E-001, -3.34408151E-001
1034, 1.35579572E+001, 8.80265597E-001, -3.45852412E-001
1035, 1.35471944E+001, 8.68592849E-001, -3.57363269E-001
1036, 1.35364599E+001, 8.56901104E-001, -3.68964437E-001
1037, 1.35257864E+001, 8.45212007E-001, -3.80610696E-001
1038, 1.35151511E+001, 8.33512431E-001, -3.92364262E-001
1039, 1.35047086E+001, 8.21944361E-001, -4.04102405E-001
1040, 1.34945426E+001, 8.10544860E-001, -4.15798448E-001
1041, 1.34843075E+001, 7.98874442E-001, -4.27855822E-001
1042, 1.34742027E+001, 7.87161312E-001, -4.40007665E-001
1043, 1.34643303E+001, 7.75515680E-001, -4.52156355E-001
1044, 1.34546123E+001, 7.63832111E-001, -4.64422387E-001
1045, 1.34450467E+001, 7.52116212E-001, -4.76795947E-001
1046, 1.34356210E+001, 7.40366887E-001, -4.89274616E-001
1047, 1.34263505E+001, 7.28608620E-001, -5.01833873E-001
1048, 1.34172264E+001, 7.16833132E-001, -5.14482573E-001
1049, 1.34082359E+001, 7.05034292E-001, -5.27228427E-001
1050, 1.33993907E+001, 6.93234970E-001, -5.40045036E-001
1051, 1.33906892E+001, 6.81430174E-001, -5.52935270E-001
1052, 1.33821332E+001, 6.69626181E-001, -5.65892584E-001
1053, 1.33736288E+001, 6.57723200E-001, -5.79031528E-001
1054, 1.33652338E+001, 6.45829520E-001, -5.92240792E-001
1055, 1.33571364E+001, 6.34176710E-001, -6.05234936E-001
1056, 1.33490464E+001, 6.22340110E-001, -6.18453740E-001
1057, 1.33409580E+001, 6.10370369E-001, -6.31843833E-001
1058, 1.33329492E+001, 5.98436657E-001, -6.45234449E-001
1059, 1.33249716E+001, 5.86494276E-001, -6.58690910E-001
1060, 1.33170628E+001, 5.74610566E-001, -6.72148036E-001
1061, 1.33092074E+001, 5.62762805E-001, -6.85632030E-001
1062, 1.33013927E+001, 5.50931258E-001, -6.99159632E-001
1063, 1.32882521E+001, 5.03667096E-001, -7.15064276E-001
1064, 1.32807197E+001, 4.91593345E-001, -7.29421872E-001
1065, 1.32732088E+001, 4.79542023E-001, -7.43810598E-001
1066, 1.32657243E+001, 4.67528325E-001, -7.58248682E-001
1067, 1.32582751E+001, 4.55566227E-001, -7.72751812E-001
1068, 1.32508720E+001, 4.43668935E-001, -7.87334182E-001
1069, 1.32435276E+001, 4.31848718E-001, -8.02009115E-001
1070, 1.32362504E+001, 4.20112000E-001, -8.16792412E-001
1071, 1.32290439E+001, 4.08469085E-001, -8.31681003E-001
1072, 1.32219066E+001, 3.96924777E-001, -8.46674681E-001
1073, 1.32148369E+001, 3.85483520E-001, -8.61773399E-001
1074, 1.32078331E+001, 3.74149672E-001, -8.76977323E-001
1075, 1.32008928E+001, 3.62927812E-001, -8.92286932E-001
1076, 1.31940129E+001, 3.51823087E-001, -9.07703198E-001
1077, 1.31871888E+001, 3.40837945E-001, -9.23224346E-001
1078, 1.31804119E+001, 3.29957789E-001, -9.38839737E-001
1079, 1.31736722E+001, 3.19165329E-001, -9.54535955E-001
1080, 1.31669596E+001, 3.08443535E-001, -9.70299663E-001
1081, 1.31602643E+001, 2.97775224E-001, -9.86117041E-001
1082, 1.31535778E+001, 2.87142702E-001, -1.00197313E+000
1083, 1.31607228E+001, 2.64268734E-001, -1.03333790E+000
1084, 1.31548318E+001, 2.54586372E-001, -1.04881785E+000
1085, 1.31489611E+001, 2.44986113E-001, -1.06435801E+000
1086, 1.31431124E+001, 2.35510715E-001, -1.07998496E+000
1087, 1.31372830E+001, 2.26185326E-001, -1.09571294E+000
1088, 1.31314617E+001, 2.17007815E-001, -1.11153709E+000
1089, 1.31256252E+001, 2.07973706E-001, -1.12745132E+000
1090, 1.31197176E+001, 1.99077815E-001, -1.14344848E+000
1091, 1.31135946E+001, 1.90299380E-001, -1.15951084E+000
1092, 1.31068725E+001, 1.81614842E-001, -1.17561128E+000
1093, 1.36049569E+001, 9.36630416E-001, -3.03652571E-001
1094, 1.36068805E+001, 9.32017766E-001, -2.95684077E-001
1095, 1.35966835E+001, 9.28433541E-001, -3.11915517E-001
1096, 1.35986988E+001, 9.23671564E-001, -3.03685791E-001
1097, 1.33035351E+001, 5.28156326E-001, -6.87063640E-001
1098, 1.33113083E+001, 5.40532579E-001, -6.73420486E-001
1099, 1.33191328E+001, 5.52879571E-001, -6.59795945E-001
1100, 1.33270160E+001, 5.65201692E-001, -6.46198981E-001
1101, 1.33349672E+001, 5.77503428E-001, -6.32638116E-001
1102, 1.33429967E+001, 5.89789254E-001, -6.19121651E-001
1103, 1.33511155E+001, 6.02063630E-001, -6.05657857E-001
1104, 1.33593350E+001, 6.14331051E-001, -5.92255131E-001
1105, 1.33676666E+001, 6.26596168E-001, -5.78922127E-001
1106, 1.33761217E+001, 6.38863869E-001, -5.65667859E-001
1107, 1.33847116E+001, 6.51139493E-001, -5.52501526E-001
1108, 1.33934435E+001, 6.63425803E-001, -5.39429421E-001
1109, 1.34023195E+001, 6.75720879E-001, -5.26453634E-001
1110, 1.34113407E+001, 6.88022753E-001, -5.13575712E-001
1111, 1.34205083E+001, 7.00329264E-001, -5.00797303E-001
1112, 1.34298235E+001, 7.12637938E-001, -4.88120086E-001
1113, 1.34392872E+001, 7.24945897E-001, -4.75545728E-001
1114, 1.34489006E+001, 7.37249791E-001, -4.63075864E-001
1115, 1.34586650E+001, 7.49545724E-001, -4.50712092E-001
1116, 1.34685819E+001, 7.61829184E-001, -4.38455986E-001
1117, 1.34786532E+001, 7.74094893E-001, -4.26309096E-001
1118, 1.34888802E+001, 7.86336137E-001, -4.14273155E-001
1119, 1.34992545E+001, 7.98551378E-001, -4.02342344E-001
1120, 1.35097622E+001, 8.10741173E-001, -3.90506565E-001
1121, 1.35203894E+001, 8.22905087E-001, -3.78755584E-001
1122, 1.35311229E+001, 8.35042505E-001, -3.67078646E-001
1123, 1.35419503E+001, 8.47152927E-001, -3.55464472E-001
1124, 1.35528592E+001, 8.59236275E-001, -3.43901270E-001
1125, 1.35638382E+001, 8.71293199E-001, -3.32376742E-001
1126, 1.35748759E+001, 8.83325426E-001, -3.20878076E-001
1127, 1.35859620E+001, 8.95336162E-001, -3.09391886E-001
1128, 1.33082741E+001, 5.01615318E-001, -7.15151983E-001
1129, 1.33006918E+001, 4.89545443E-001, -7.29513440E-001
1130, 1.32931630E+001, 4.77490837E-001, -7.43915708E-001
1131, 1.32856872E+001, 4.65465614E-001, -7.58369546E-001
1132, 1.32782640E+001, 4.53483794E-001, -7.72885804E-001
1133, 1.32708932E+001, 4.41559313E-001, -7.87475359E-001
1134, 1.32635741E+001, 4.29706162E-001, -8.02148882E-001
1135, 1.32563072E+001, 4.17936702E-001, -8.16916054E-001
1136, 1.32490918E+001, 4.06258191E-001, -8.31781112E-001
1137, 1.32419279E+001, 3.94676447E-001, -8.46747342E-001
1138, 1.32348156E+001, 3.83197505E-001, -8.61817827E-001
1139, 1.32277551E+001, 3.71827553E-001, -8.76995543E-001
1140, 1.32207465E+001, 3.60572972E-001, -8.92283285E-001
1141, 1.32137902E+001, 3.49440319E-001, -9.07683668E-001
1142, 1.32068867E+001, 3.38432146E-001, -9.23196180E-001
1143, 1.32000369E+001, 3.27533705E-001, -9.38808936E-001
1144, 1.31932421E+001, 3.16725476E-001, -9.54507652E-001
1145, 1.31865029E+001, 3.05987568E-001, -9.70278435E-001
1146, 1.31798201E+001, 2.95299885E-001, -9.86107515E-001
1147, 1.31731939E+001, 2.84642306E-001, -1.00198091E+000
1148, 1.36050904E+001, 9.15787347E-001, -2.90182064E-001
1149, 1.36131837E+001, 9.24258398E-001, -2.82437868E-001
1150, 1.36089862E+001, 8.94241273E-001, -3.07573534E-001
1151, 1.35976066E+001, 8.82289276E-001, -3.19002816E-001
1152, 1.35863482E+001, 8.70283675E-001, -3.30496686E-001
1153, 1.35752127E+001, 8.58228697E-001, -3.42058249E-001
1154, 1.35642008E+001, 8.46128406E-001, -3.53690556E-001
1155, 1.35533135E+001, 8.33986725E-001, -3.65396536E-001
1156, 1.35425514E+001, 8.21807482E-001, -3.77178898E-001
1157, 1.35319154E+001, 8.09594361E-001, -3.89040143E-001
1158, 1.35214063E+001, 7.97350725E-001, -4.00982737E-001
1159, 1.35110245E+001, 7.85080047E-001, -4.13008638E-001
1160, 1.35007706E+001, 7.72785529E-001, -4.25119714E-001
1161, 1.34906471E+001, 7.60469370E-001, -4.37318737E-001
1162, 1.34806522E+001, 7.48135960E-001, -4.49606188E-001
1163, 1.34707869E+001, 7.35788331E-001, -4.61984181E-001
1164, 1.34610517E+001, 7.23429884E-001, -4.74454548E-001
1165, 1.34514470E+001, 7.11064195E-001, -4.87019037E-001
1166, 1.34419731E+001, 6.98694843E-001, -4.99679507E-001
1167, 1.34326305E+001, 6.86325527E-001, -5.12437780E-001
1168, 1.34234195E+001, 6.73960057E-001, -5.25295657E-001
1169, 1.34143406E+001, 6.61602326E-001, -5.38254942E-001
1170, 1.34053939E+001, 6.49256301E-001, -5.51317430E-001
1171, 1.33965806E+001, 6.36925865E-001, -5.64484409E-001
1172, 1.33879007E+001, 6.24610049E-001, -5.77752917E-001
1173, 1.33793554E+001, 6.12303975E-001, -5.91117916E-001
1174, 1.33709438E+001, 6.00005499E-001, -6.04571074E-001
1175, 1.33626689E+001, 5.87707250E-001, -6.18110250E-001
1176, 1.33545363E+001, 5.75398314E-001, -6.31737646E-001
1177, 1.33465200E+001, 5.63108857E-001, -6.45406042E-001
1178, 1.33386684E+001, 5.50772573E-001, -6.59184215E-001
1179, 1.33310845E+001, 5.38252130E-001, -6.73227772E-001
1180, 1.33235774E+001, 5.25790411E-001, -6.87231629E-001
1181, 1.36368850E+001, 9.23131298E-001, -2.80705630E-001
1182, 1.36286687E+001, 9.14613714E-001, -2.88432032E-001
**
** Elements ++++++++++++++++++++++++++++++++++++++++++++++++
**
*Element, Type=S3, Elset=Shell_part-1
1, 1, 54, 75
2, 75, 54, 615
3, 75, 615, 74
4, 74, 615, 616
5, 74, 616, 73
6, 73, 616, 617
7, 73, 617, 72
8, 72, 617, 618
9, 72, 618, 71
10, 71, 618, 619
11, 71, 619, 70
12, 70, 619, 620
13, 70, 620, 69
14, 69, 620, 621
15, 69, 621, 68
16, 68, 621, 622
17, 68, 622, 67
18, 67, 622, 623
19, 67, 623, 66
20, 66, 623, 624
21, 66, 624, 4
22, 4, 624, 65
23, 54, 2, 615
24, 615, 2, 55
25, 615, 55, 616
26, 616, 55, 56
27, 616, 56, 617
28, 617, 56, 57
29, 617, 57, 618
30, 618, 57, 58
31, 618, 58, 619
32, 619, 58, 59
33, 619, 59, 620
34, 620, 59, 60
35, 620, 60, 621
36, 621, 60, 61
37, 621, 61, 622
38, 622, 61, 62
39, 622, 62, 623
40, 623, 62, 63
41, 623, 63, 624
42, 624, 63, 64
43, 624, 64, 65
44, 65, 64, 3
45, 5, 76, 96
46, 96, 76, 625
47, 96, 625, 95
48, 95, 625, 626
49, 95, 626, 94
50, 94, 626, 627
51, 94, 627, 93
52, 93, 627, 628
53, 93, 628, 92
54, 92, 628, 629
55, 92, 629, 91
56, 91, 629, 630
57, 91, 630, 90
58, 90, 630, 631
59, 90, 631, 89
60, 89, 631, 632
61, 89, 632, 88
62, 88, 632, 633
63, 88, 633, 87
64, 87, 633, 634
65, 87, 634, 1
66, 1, 634, 54
67, 76, 6, 625
68, 625, 6, 77
69, 625, 77, 626
70, 626, 77, 78
71, 626, 78, 627
72, 627, 78, 79
73, 627, 79, 628
74, 628, 79, 80
75, 628, 80, 629
76, 629, 80, 81
77, 629, 81, 630
78, 630, 81, 82
79, 630, 82, 631
80, 631, 82, 83
81, 631, 83, 632
82, 632, 83, 84
83, 632, 84, 633
84, 633, 84, 85
85, 633, 85, 634
86, 634, 85, 86
87, 634, 86, 54
88, 54, 86, 2
89, 7, 97, 108
90, 108, 97, 635
91, 108, 635, 2
92, 2, 635, 55
93, 97, 98, 635
94, 635, 98, 636
95, 635, 636, 55
96, 55, 636, 56
97, 98, 99, 636
98, 636, 99, 637
99, 636, 637, 56
100, 56, 637, 57
101, 99, 100, 637
102, 637, 100, 638
103, 637, 638, 57
104, 57, 638, 58
105, 100, 101, 638
106, 638, 101, 639
107, 638, 639, 58
108, 58, 639, 59
109, 101, 102, 639
110, 639, 102, 640
111, 639, 640, 59
112, 59, 640, 60
113, 102, 103, 640
114, 640, 103, 641
115, 640, 641, 60
116, 60, 641, 61
117, 103, 104, 641
118, 641, 104, 642
119, 641, 642, 61
120, 61, 642, 62
121, 104, 105, 642
122, 642, 105, 643
123, 642, 643, 62
124, 62, 643, 63
125, 105, 106, 643
126, 643, 106, 644
127, 643, 644, 63
128, 63, 644, 64
129, 106, 8, 644
130, 644, 8, 107
131, 644, 107, 64
132, 64, 107, 3
133, 9, 109, 113
134, 113, 109, 645
135, 113, 645, 112
136, 112, 645, 646
137, 112, 646, 3
138, 3, 646, 65
139, 109, 10, 645
140, 645, 10, 110
141, 645, 110, 646
142, 646, 110, 111
143, 646, 111, 65
144, 65, 111, 4
145, 11, 114, 134
146, 134, 114, 647
147, 134, 647, 133
148, 133, 647, 648
149, 133, 648, 132
150, 132, 648, 649
151, 132, 649, 131
152, 131, 649, 650
153, 131, 650, 130
154, 130, 650, 651
155, 130, 651, 129
156, 129, 651, 652
157, 129, 652, 128
158, 128, 652, 653
159, 128, 653, 127
160, 127, 653, 654
161, 127, 654, 126
162, 126, 654, 655
163, 126, 655, 125
164, 125, 655, 656
165, 125, 656, 5
166, 5, 656, 76
167, 114, 12, 647
168, 647, 12, 115
169, 647, 115, 648
170, 648, 115, 116
171, 648, 116, 649
172, 649, 116, 117
173, 649, 117, 650
174, 650, 117, 118
175, 650, 118, 651
176, 651, 118, 119
177, 651, 119, 652
178, 652, 119, 120
179, 652, 120, 653
180, 653, 120, 121
181, 653, 121, 654
182, 654, 121, 122
183, 654, 122, 655
184, 655, 122, 123
185, 655, 123, 656
186, 656, 123, 124
187, 656, 124, 76
188, 76, 124, 6
189, 13, 135, 145
190, 145, 135, 657
191, 145, 657, 6
192, 6, 657, 77
193, 135, 136, 657
194, 657, 136, 658
195, 657, 658, 77
196, 77, 658, 78
197, 136, 137, 658
198, 658, 137, 659
199, 658, 659, 78
200, 78, 659, 79
201, 137, 138, 659
202, 659, 138, 660
203, 659, 660, 79
204, 79, 660, 80
205, 138, 139, 660
206, 660, 139, 661
207, 660, 661, 80
208, 80, 661, 81
209, 139, 140, 661
210, 661, 140, 662
211, 661, 662, 81
212, 81, 662, 82
213, 140, 141, 662
214, 662, 141, 663
215, 662, 663, 82
216, 82, 663, 83
217, 141, 142, 663
218, 663, 142, 664
219, 663, 664, 83
220, 83, 664, 84
221, 142, 143, 664
222, 664, 143, 665
223, 664, 665, 84
224, 84, 665, 85
225, 143, 144, 665
226, 665, 144, 666
227, 665, 666, 85
228, 85, 666, 86
229, 144, 7, 666
230, 666, 7, 108
231, 666, 108, 86
232, 86, 108, 2
233, 100, 677, 671
234, 146, 668, 7
235, 679, 683, 678
236, 146, 706, 694
237, 677, 679, 678
238, 157, 687, 156
239, 160, 689, 159
240, 676, 677, 99
241, 667, 689, 160
242, 16, 686, 157
243, 677, 678, 671
244, 99, 677, 100
245, 686, 687, 157
246, 685, 700, 667
247, 683, 684, 672
248, 98, 676, 99
249, 14, 705, 147
250, 669, 707, 695
251, 672, 693, 683
252, 106, 685, 8
253, 670, 703, 697
254, 674, 711, 699
255, 699, 708, 674
256, 146, 694, 668
257, 695, 707, 697
258, 678, 683, 681
259, 693, 712, 692
260, 159, 689, 673
261, 683, 693, 681
262, 17, 667, 160
263, 693, 714, 712
264, 697, 703, 698
265, 106, 700, 685
266, 684, 702, 672
267, 147, 706, 146
268, 158, 686, 16
269, 667, 710, 689
270, 702, 706, 705
271, 684, 706, 702
272, 694, 706, 684
273, 668, 694, 676
274, 681, 693, 692
275, 679, 694, 684
276, 687, 713, 156
277, 678, 680, 671
278, 676, 679, 677
279, 675, 708, 699
280, 673, 687, 686
281, 697, 707, 670
282, 17, 685, 667
283, 673, 689, 688
284, 675, 709, 692
285, 159, 673, 158
286, 149, 702, 148
287, 668, 676, 98
288, 680, 701, 671
289, 105, 700, 106
290, 678, 681, 680
291, 102, 701, 670
292, 673, 688, 687
293, 699, 709, 675
294, 701, 703, 670
295, 150, 672, 149
296, 153, 675, 152
297, 155, 674, 154
298, 101, 701, 102
299, 681, 682, 680
300, 695, 697, 696
301, 692, 712, 675
302, 698, 703, 682
303, 689, 690, 688
304, 697, 698, 696
305, 104, 669, 105
306, 102, 670, 103
307, 100, 671, 101
308, 671, 701, 101
309, 681, 692, 682
310, 698, 699, 696
311, 695, 696, 691
312, 690, 695, 691
313, 679, 684, 683
314, 669, 700, 105
315, 680, 703, 701
316, 672, 702, 149
317, 702, 705, 148
318, 690, 691, 688
319, 104, 707, 669
320, 670, 707, 103
321, 682, 703, 680
322, 148, 705, 14
323, 692, 709, 682
324, 673, 686, 158
325, 688, 704, 687
326, 153, 708, 675
327, 674, 708, 154
328, 103, 707, 104
329, 674, 713, 704
330, 672, 714, 693
331, 682, 709, 698
332, 691, 704, 688
333, 675, 712, 152
334, 155, 713, 674
335, 150, 714, 672
336, 699, 711, 696
337, 704, 711, 674
338, 695, 715, 669
339, 676, 694, 679
340, 700, 710, 667
341, 97, 668, 98
342, 704, 713, 687
343, 698, 709, 699
344, 691, 711, 704
345, 154, 708, 153
346, 690, 715, 695
347, 689, 710, 690
348, 8, 685, 17
349, 152, 712, 151
350, 696, 711, 691
351, 156, 713, 155
352, 712, 714, 151
353, 151, 714, 150
354, 669, 715, 700
355, 705, 706, 147
356, 700, 715, 710
357, 710, 715, 690
358, 7, 668, 97
359, 15, 16, 157
360, 8, 161, 107
361, 161, 716, 107
362, 161, 162, 716
363, 162, 717, 716
364, 162, 18, 717
365, 18, 163, 717
366, 107, 716, 3
367, 716, 112, 3
368, 716, 717, 112
369, 717, 113, 112
370, 717, 163, 113
371, 163, 9, 113
372, 11, 164, 114
373, 114, 164, 718
374, 114, 718, 12
375, 12, 718, 204
376, 164, 165, 718
377, 718, 165, 719
378, 718, 719, 204
379, 204, 719, 203
380, 165, 166, 719
381, 719, 166, 720
382, 719, 720, 203
383, 203, 720, 202
384, 166, 167, 720
385, 720, 167, 721
386, 720, 721, 202
387, 202, 721, 201
388, 167, 168, 721
389, 721, 168, 722
390, 721, 722, 201
391, 201, 722, 200
392, 168, 169, 722
393, 722, 169, 723
394, 722, 723, 200
395, 200, 723, 199
396, 169, 170, 723
397, 723, 170, 724
398, 723, 724, 199
399, 199, 724, 198
400, 170, 171, 724
401, 724, 171, 725
402, 724, 725, 198
403, 198, 725, 197
404, 171, 172, 725
405, 725, 172, 726
406, 725, 726, 197
407, 197, 726, 196
408, 172, 173, 726
409, 726, 173, 727
410, 726, 727, 196
411, 196, 727, 195
412, 173, 174, 727
413, 727, 174, 728
414, 727, 728, 195
415, 195, 728, 194
416, 174, 175, 728
417, 728, 175, 729
418, 728, 729, 194
419, 194, 729, 193
420, 175, 176, 729
421, 729, 176, 730
422, 729, 730, 193
423, 193, 730, 192
424, 176, 177, 730
425, 730, 177, 731
426, 730, 731, 192
427, 192, 731, 191
428, 177, 178, 731
429, 731, 178, 732
430, 731, 732, 191
431, 191, 732, 190
432, 178, 179, 732
433, 732, 179, 733
434, 732, 733, 190
435, 190, 733, 189
436, 179, 180, 733
437, 733, 180, 734
438, 733, 734, 189
439, 189, 734, 188
440, 180, 181, 734
441, 734, 181, 735
442, 734, 735, 188
443, 188, 735, 187
444, 181, 182, 735
445, 735, 182, 736
446, 735, 736, 187
447, 187, 736, 186
448, 182, 183, 736
449, 736, 183, 737
450, 736, 737, 186
451, 186, 737, 185
452, 183, 19, 737
453, 737, 19, 184
454, 737, 184, 185
455, 185, 184, 20
456, 6, 124, 145
457, 124, 738, 145
458, 124, 123, 738
459, 123, 739, 738
460, 123, 122, 739
461, 122, 740, 739
462, 122, 121, 740
463, 121, 741, 740
464, 121, 120, 741
465, 120, 742, 741
466, 120, 119, 742
467, 119, 743, 742
468, 119, 118, 743
469, 118, 744, 743
470, 118, 117, 744
471, 117, 745, 744
472, 117, 116, 745
473, 116, 746, 745
474, 116, 115, 746
475, 115, 747, 746
476, 115, 12, 747
477, 12, 205, 747
478, 145, 738, 13
479, 738, 215, 13
480, 738, 739, 215
481, 739, 214, 215
482, 739, 740, 214
483, 740, 213, 214
484, 740, 741, 213
485, 741, 212, 213
486, 741, 742, 212
487, 742, 211, 212
488, 742, 743, 211
489, 743, 210, 211
490, 743, 744, 210
491, 744, 209, 210
492, 744, 745, 209
493, 745, 208, 209
494, 745, 746, 208
495, 746, 207, 208
496, 746, 747, 207
497, 747, 206, 207
498, 747, 205, 206
499, 205, 21, 206
500, 13, 216, 135
501, 135, 216, 748
502, 135, 748, 136
503, 136, 748, 749
504, 136, 749, 137
505, 137, 749, 750
506, 137, 750, 138
507, 138, 750, 751
508, 138, 751, 139
509, 139, 751, 752
510, 139, 752, 140
511, 140, 752, 753
512, 140, 753, 141
513, 141, 753, 754
514, 141, 754, 142
515, 142, 754, 755
516, 142, 755, 143
517, 143, 755, 756
518, 143, 756, 144
519, 144, 756, 757
520, 144, 757, 7
521, 7, 757, 146
522, 216, 217, 748
523, 748, 217, 758
524, 748, 758, 749
525, 749, 758, 759
526, 749, 759, 750
527, 750, 759, 760
528, 750, 760, 751
529, 751, 760, 761
530, 751, 761, 752
531, 752, 761, 762
532, 752, 762, 753
533, 753, 762, 763
534, 753, 763, 754
535, 754, 763, 764
536, 754, 764, 755
537, 755, 764, 765
538, 755, 765, 756
539, 756, 765, 766
540, 756, 766, 757
541, 757, 766, 767
542, 757, 767, 146
543, 146, 767, 147
544, 217, 22, 758
545, 758, 22, 218
546, 758, 218, 759
547, 759, 218, 219
548, 759, 219, 760
549, 760, 219, 220
550, 760, 220, 761
551, 761, 220, 221
552, 761, 221, 762
553, 762, 221, 222
554, 762, 222, 763
555, 763, 222, 223
556, 763, 223, 764
557, 764, 223, 224
558, 764, 224, 765
559, 765, 224, 225
560, 765, 225, 766
561, 766, 225, 226
562, 766, 226, 767
563, 767, 226, 227
564, 767, 227, 147
565, 147, 227, 14
566, 23, 228, 239
567, 239, 228, 768
568, 239, 768, 14
569, 14, 768, 148
570, 228, 229, 768
571, 768, 229, 769
572, 768, 769, 148
573, 148, 769, 149
574, 229, 230, 769
575, 769, 230, 770
576, 769, 770, 149
577, 149, 770, 150
578, 230, 231, 770
579, 770, 231, 771
580, 770, 771, 150
581, 150, 771, 151
582, 231, 232, 771
583, 771, 232, 772
584, 771, 772, 151
585, 151, 772, 152
586, 232, 233, 772
587, 772, 233, 773
588, 772, 773, 152
589, 152, 773, 153
590, 233, 234, 773
591, 773, 234, 774
592, 773, 774, 153
593, 153, 774, 154
594, 234, 235, 774
595, 774, 235, 775
596, 774, 775, 154
597, 154, 775, 155
598, 235, 236, 775
599, 775, 236, 776
600, 775, 776, 155
601, 155, 776, 156
602, 236, 237, 776
603, 776, 237, 777
604, 776, 777, 156
605, 156, 777, 157
606, 237, 24, 777
607, 777, 24, 238
608, 777, 238, 157
609, 157, 238, 15
610, 27, 778, 245
611, 785, 803, 791
612, 794, 811, 797
613, 781, 800, 778
614, 778, 800, 245
615, 797, 811, 789
616, 162, 814, 18
617, 246, 791, 29
618, 158, 803, 785
619, 247, 805, 789
620, 27, 779, 778
621, 782, 802, 799
622, 16, 810, 29
623, 795, 798, 786
624, 792, 802, 801
625, 789, 805, 797
626, 160, 801, 17
627, 798, 807, 786
628, 791, 803, 29
629, 799, 802, 792
630, 792, 801, 160
631, 785, 792, 159
632, 784, 806, 781
633, 158, 785, 159
634, 781, 806, 800
635, 159, 792, 160
636, 788, 806, 796
637, 17, 812, 8
638, 787, 793, 162
639, 250, 786, 249
640, 247, 789, 246
641, 244, 788, 243
642, 29, 803, 16
643, 796, 806, 798
644, 799, 811, 794
645, 789, 791, 246
646, 27, 793, 779
647, 8, 812, 161
648, 242, 796, 241
649, 161, 787, 162
650, 28, 810, 15
651, 245, 800, 244
652, 787, 813, 793
653, 804, 805, 248
654, 249, 804, 248
655, 241, 795, 240
656, 27, 814, 793
657, 783, 790, 784
658, 785, 799, 792
659, 241, 796, 795
660, 783, 784, 781
661, 783, 797, 790
662, 789, 811, 791
663, 780, 794, 783
664, 793, 814, 162
665, 240, 808, 25
666, 26, 809, 242
667, 25, 808, 250
668, 780, 783, 781
669, 243, 809, 26
670, 796, 798, 795
671, 782, 794, 780
672, 780, 781, 778
673, 779, 782, 780
674, 244, 800, 788
675, 794, 797, 783
676, 248, 805, 247
677, 790, 805, 804
678, 779, 780, 778
679, 801, 802, 787
680, 782, 799, 794
681, 786, 804, 249
682, 242, 809, 796
683, 791, 811, 785
684, 796, 809, 788
685, 802, 813, 787
686, 250, 808, 786
687, 788, 809, 243
688, 786, 808, 795
689, 798, 806, 784
690, 786, 807, 804
691, 29, 810, 28
692, 161, 812, 787
693, 784, 807, 798
694, 797, 805, 790
695, 790, 807, 784
696, 15, 810, 16
697, 795, 808, 240
698, 800, 806, 788
699, 801, 812, 17
700, 18, 814, 27
701, 785, 811, 799
702, 779, 813, 782
703, 804, 807, 790
704, 782, 813, 802
705, 787, 812, 801
706, 793, 813, 779
707, 16, 803, 158
708, 30, 251, 313
709, 313, 251, 815
710, 313, 815, 312
711, 312, 815, 816
712, 312, 816, 311
713, 311, 816, 817
714, 311, 817, 310
715, 310, 817, 818
716, 310, 818, 309
717, 309, 818, 819
718, 309, 819, 308
719, 308, 819, 820
720, 308, 820, 307
721, 307, 820, 821
722, 307, 821, 306
723, 306, 821, 822
724, 306, 822, 305
725, 305, 822, 823
726, 305, 823, 304
727, 304, 823, 824
728, 304, 824, 303
729, 303, 824, 825
730, 303, 825, 302
731, 302, 825, 826
732, 302, 826, 301
733, 301, 826, 827
734, 301, 827, 300
735, 300, 827, 828
736, 300, 828, 299
737, 299, 828, 829
738, 299, 829, 298
739, 298, 829, 830
740, 298, 830, 297
741, 297, 830, 831
742, 297, 831, 296
743, 296, 831, 832
744, 296, 832, 295
745, 295, 832, 833
746, 295, 833, 294
747, 294, 833, 834
748, 294, 834, 293
749, 293, 834, 835
750, 293, 835, 292
751, 292, 835, 836
752, 292, 836, 291
753, 291, 836, 837
754, 291, 837, 290
755, 290, 837, 838
756, 290, 838, 289
757, 289, 838, 839
758, 289, 839, 288
759, 288, 839, 840
760, 288, 840, 287
761, 287, 840, 841
762, 287, 841, 286
763, 286, 841, 842
764, 286, 842, 285
765, 285, 842, 843
766, 285, 843, 284
767, 284, 843, 844
768, 284, 844, 283
769, 283, 844, 845
770, 283, 845, 19
771, 19, 845, 184
772, 251, 31, 815
773, 815, 31, 252
774, 815, 252, 816
775, 816, 252, 253
776, 816, 253, 817
777, 817, 253, 254
778, 817, 254, 818
779, 818, 254, 255
780, 818, 255, 819
781, 819, 255, 256
782, 819, 256, 820
783, 820, 256, 257
784, 820, 257, 821
785, 821, 257, 258
786, 821, 258, 822
787, 822, 258, 259
788, 822, 259, 823
789, 823, 259, 260
790, 823, 260, 824
791, 824, 260, 261
792, 824, 261, 825
793, 825, 261, 262
794, 825, 262, 826
795, 826, 262, 263
796, 826, 263, 827
797, 827, 263, 264
798, 827, 264, 828
799, 828, 264, 265
800, 828, 265, 829
801, 829, 265, 266
802, 829, 266, 830
803, 830, 266, 267
804, 830, 267, 831
805, 831, 267, 268
806, 831, 268, 832
807, 832, 268, 269
808, 832, 269, 833
809, 833, 269, 270
810, 833, 270, 834
811, 834, 270, 271
812, 834, 271, 835
813, 835, 271, 272
814, 835, 272, 836
815, 836, 272, 273
816, 836, 273, 837
817, 837, 273, 274
818, 837, 274, 838
819, 838, 274, 275
820, 838, 275, 839
821, 839, 275, 276
822, 839, 276, 840
823, 840, 276, 277
824, 840, 277, 841
825, 841, 277, 278
826, 841, 278, 842
827, 842, 278, 279
828, 842, 279, 843
829, 843, 279, 280
830, 843, 280, 844
831, 844, 280, 281
832, 844, 281, 845
833, 845, 281, 282
834, 845, 282, 184
835, 184, 282, 20
836, 32, 314, 334
837, 334, 314, 846
838, 334, 846, 20
839, 20, 846, 185
840, 314, 315, 846
841, 846, 315, 847
842, 846, 847, 185
843, 185, 847, 186
844, 315, 316, 847
845, 847, 316, 848
846, 847, 848, 186
847, 186, 848, 187
848, 316, 317, 848
849, 848, 317, 849
850, 848, 849, 187
851, 187, 849, 188
852, 317, 318, 849
853, 849, 318, 850
854, 849, 850, 188
855, 188, 850, 189
856, 318, 319, 850
857, 850, 319, 851
858, 850, 851, 189
859, 189, 851, 190
860, 319, 320, 851
861, 851, 320, 852
862, 851, 852, 190
863, 190, 852, 191
864, 320, 321, 852
865, 852, 321, 853
866, 852, 853, 191
867, 191, 853, 192
868, 321, 322, 853
869, 853, 322, 854
870, 853, 854, 192
871, 192, 854, 193
872, 322, 323, 854
873, 854, 323, 855
874, 854, 855, 193
875, 193, 855, 194
876, 323, 324, 855
877, 855, 324, 856
878, 855, 856, 194
879, 194, 856, 195
880, 324, 325, 856
881, 856, 325, 857
882, 856, 857, 195
883, 195, 857, 196
884, 325, 326, 857
885, 857, 326, 858
886, 857, 858, 196
887, 196, 858, 197
888, 326, 327, 858
889, 858, 327, 859
890, 858, 859, 197
891, 197, 859, 198
892, 327, 328, 859
893, 859, 328, 860
894, 859, 860, 198
895, 198, 860, 199
896, 328, 329, 860
897, 860, 329, 861
898, 860, 861, 199
899, 199, 861, 200
900, 329, 330, 861
901, 861, 330, 862
902, 861, 862, 200
903, 200, 862, 201
904, 330, 331, 862
905, 862, 331, 863
906, 862, 863, 201
907, 201, 863, 202
908, 331, 332, 863
909, 863, 332, 864
910, 863, 864, 202
911, 202, 864, 203
912, 332, 333, 864
913, 864, 333, 865
914, 864, 865, 203
915, 203, 865, 204
916, 333, 21, 865
917, 865, 21, 205
918, 865, 205, 204
919, 204, 205, 12
920, 21, 335, 206
921, 206, 335, 866
922, 206, 866, 207
923, 207, 866, 867
924, 207, 867, 208
925, 208, 867, 868
926, 208, 868, 209
927, 209, 868, 869
928, 209, 869, 210
929, 210, 869, 870
930, 210, 870, 211
931, 211, 870, 871
932, 211, 871, 212
933, 212, 871, 872
934, 212, 872, 213
935, 213, 872, 873
936, 213, 873, 214
937, 214, 873, 874
938, 214, 874, 215
939, 215, 874, 875
940, 215, 875, 13
941, 13, 875, 216
942, 335, 336, 866
943, 866, 336, 876
944, 866, 876, 867
945, 867, 876, 877
946, 867, 877, 868
947, 868, 877, 878
948, 868, 878, 869
949, 869, 878, 879
950, 869, 879, 870
951, 870, 879, 880
952, 870, 880, 871
953, 871, 880, 881
954, 871, 881, 872
955, 872, 881, 882
956, 872, 882, 873
957, 873, 882, 883
958, 873, 883, 874
959, 874, 883, 884
960, 874, 884, 875
961, 875, 884, 885
962, 875, 885, 216
963, 216, 885, 217
964, 336, 33, 876
965, 876, 33, 337
966, 876, 337, 877
967, 877, 337, 338
968, 877, 338, 878
969, 878, 338, 339
970, 878, 339, 879
971, 879, 339, 340
972, 879, 340, 880
973, 880, 340, 341
974, 880, 341, 881
975, 881, 341, 342
976, 881, 342, 882
977, 882, 342, 343
978, 882, 343, 883
979, 883, 343, 344
980, 883, 344, 884
981, 884, 344, 345
982, 884, 345, 885
983, 885, 345, 346
984, 885, 346, 217
985, 217, 346, 22
986, 34, 347, 357
987, 357, 347, 886
988, 357, 886, 22
989, 22, 886, 218
990, 347, 348, 886
991, 886, 348, 887
992, 886, 887, 218
993, 218, 887, 219
994, 348, 349, 887
995, 887, 349, 888
996, 887, 888, 219
997, 219, 888, 220
998, 349, 350, 888
999, 888, 350, 889
1000, 888, 889, 220
1001, 220, 889, 221
1002, 350, 351, 889
1003, 889, 351, 890
1004, 889, 890, 221
1005, 221, 890, 222
1006, 351, 352, 890
1007, 890, 352, 891
1008, 890, 891, 222
1009, 222, 891, 223
1010, 352, 353, 891
1011, 891, 353, 892
1012, 891, 892, 223
1013, 223, 892, 224
1014, 353, 354, 892
1015, 892, 354, 893
1016, 892, 893, 224
1017, 224, 893, 225
1018, 354, 355, 893
1019, 893, 355, 894
1020, 893, 894, 225
1021, 225, 894, 226
1022, 355, 356, 894
1023, 894, 356, 895
1024, 894, 895, 226
1025, 226, 895, 227
1026, 356, 23, 895
1027, 895, 23, 239
1028, 895, 239, 227
1029, 227, 239, 14
1030, 23, 358, 228
1031, 228, 358, 896
1032, 228, 896, 229
1033, 229, 896, 897
1034, 229, 897, 230
1035, 230, 897, 898
1036, 230, 898, 231
1037, 231, 898, 899
1038, 231, 899, 232
1039, 232, 899, 900
1040, 232, 900, 233
1041, 233, 900, 901
1042, 233, 901, 234
1043, 234, 901, 902
1044, 234, 902, 235
1045, 235, 902, 903
1046, 235, 903, 236
1047, 236, 903, 904
1048, 236, 904, 237
1049, 237, 904, 905
1050, 237, 905, 24
1051, 24, 905, 369
1052, 358, 35, 896
1053, 896, 35, 359
1054, 896, 359, 897
1055, 897, 359, 360
1056, 897, 360, 898
1057, 898, 360, 361
1058, 898, 361, 899
1059, 899, 361, 362
1060, 899, 362, 900
1061, 900, 362, 363
1062, 900, 363, 901
1063, 901, 363, 364
1064, 901, 364, 902
1065, 902, 364, 365
1066, 902, 365, 903
1067, 903, 365, 366
1068, 903, 366, 904
1069, 904, 366, 367
1070, 904, 367, 905
1071, 905, 367, 368
1072, 905, 368, 369
1073, 369, 368, 36
1074, 24, 37, 238
1075, 37, 370, 238
1076, 238, 370, 15
1077, 370, 28, 15
1078, 30, 371, 251
1079, 251, 371, 906
1080, 251, 906, 31
1081, 31, 906, 375
1082, 371, 372, 906
1083, 906, 372, 907
1084, 906, 907, 375
1085, 375, 907, 374
1086, 372, 38, 907
1087, 907, 38, 373
1088, 907, 373, 374
1089, 374, 373, 39
1090, 20, 282, 334
1091, 282, 908, 334
1092, 282, 281, 908
1093, 281, 909, 908
1094, 281, 280, 909
1095, 280, 910, 909
1096, 280, 279, 910
1097, 279, 911, 910
1098, 279, 278, 911
1099, 278, 912, 911
1100, 278, 277, 912
1101, 277, 913, 912
1102, 277, 276, 913
1103, 276, 914, 913
1104, 276, 275, 914
1105, 275, 915, 914
1106, 275, 274, 915
1107, 274, 916, 915
1108, 274, 273, 916
1109, 273, 917, 916
1110, 273, 272, 917
1111, 272, 918, 917
1112, 272, 271, 918
1113, 271, 919, 918
1114, 271, 270, 919
1115, 270, 920, 919
1116, 270, 269, 920
1117, 269, 921, 920
1118, 269, 268, 921
1119, 268, 922, 921
1120, 268, 267, 922
1121, 267, 923, 922
1122, 267, 266, 923
1123, 266, 924, 923
1124, 266, 265, 924
1125, 265, 925, 924
1126, 265, 264, 925
1127, 264, 926, 925
1128, 264, 263, 926
1129, 263, 927, 926
1130, 263, 262, 927
1131, 262, 928, 927
1132, 262, 261, 928
1133, 261, 929, 928
1134, 261, 260, 929
1135, 260, 930, 929
1136, 260, 259, 930
1137, 259, 931, 930
1138, 259, 258, 931
1139, 258, 932, 931
1140, 258, 257, 932
1141, 257, 933, 932
1142, 257, 256, 933
1143, 256, 934, 933
1144, 256, 255, 934
1145, 255, 935, 934
1146, 255, 254, 935
1147, 254, 936, 935
1148, 254, 253, 936
1149, 253, 937, 936
1150, 253, 252, 937
1151, 252, 938, 937
1152, 252, 31, 938
1153, 31, 376, 938
1154, 334, 908, 32
1155, 908, 407, 32
1156, 908, 909, 407
1157, 909, 406, 407
1158, 909, 910, 406
1159, 910, 405, 406
1160, 910, 911, 405
1161, 911, 404, 405
1162, 911, 912, 404
1163, 912, 403, 404
1164, 912, 913, 403
1165, 913, 402, 403
1166, 913, 914, 402
1167, 914, 401, 402
1168, 914, 915, 401
1169, 915, 400, 401
1170, 915, 916, 400
1171, 916, 399, 400
1172, 916, 917, 399
1173, 917, 398, 399
1174, 917, 918, 398
1175, 918, 397, 398
1176, 918, 919, 397
1177, 919, 396, 397
1178, 919, 920, 396
1179, 920, 395, 396
1180, 920, 921, 395
1181, 921, 394, 395
1182, 921, 922, 394
1183, 922, 393, 394
1184, 922, 923, 393
1185, 923, 392, 393
1186, 923, 924, 392
1187, 924, 391, 392
1188, 924, 925, 391
1189, 925, 390, 391
1190, 925, 926, 390
1191, 926, 389, 390
1192, 926, 927, 389
1193, 927, 388, 389
1194, 927, 928, 388
1195, 928, 387, 388
1196, 928, 929, 387
1197, 929, 386, 387
1198, 929, 930, 386
1199, 930, 385, 386
1200, 930, 931, 385
1201, 931, 384, 385
1202, 931, 932, 384
1203, 932, 383, 384
1204, 932, 933, 383
1205, 933, 382, 383
1206, 933, 934, 382
1207, 934, 381, 382
1208, 934, 935, 381
1209, 935, 380, 381
1210, 935, 936, 380
1211, 936, 379, 380
1212, 936, 937, 379
1213, 937, 378, 379
1214, 937, 938, 378
1215, 938, 377, 378
1216, 938, 376, 377
1217, 376, 40, 377
1218, 32, 408, 314
1219, 314, 408, 939
1220, 314, 939, 315
1221, 315, 939, 940
1222, 315, 940, 316
1223, 316, 940, 941
1224, 316, 941, 317
1225, 317, 941, 942
1226, 317, 942, 318
1227, 318, 942, 943
1228, 318, 943, 319
1229, 319, 943, 944
1230, 319, 944, 320
1231, 320, 944, 945
1232, 320, 945, 321
1233, 321, 945, 946
1234, 321, 946, 322
1235, 322, 946, 947
1236, 322, 947, 323
1237, 323, 947, 948
1238, 323, 948, 324
1239, 324, 948, 949
1240, 324, 949, 325
1241, 325, 949, 950
1242, 325, 950, 326
1243, 326, 950, 951
1244, 326, 951, 327
1245, 327, 951, 952
1246, 327, 952, 328
1247, 328, 952, 953
1248, 328, 953, 329
1249, 329, 953, 954
1250, 329, 954, 330
1251, 330, 954, 955
1252, 330, 955, 331
1253, 331, 955, 956
1254, 331, 956, 332
1255, 332, 956, 957
1256, 332, 957, 333
1257, 333, 957, 958
1258, 333, 958, 21
1259, 21, 958, 335
1260, 408, 409, 939
1261, 939, 409, 959
1262, 939, 959, 940
1263, 940, 959, 960
1264, 940, 960, 941
1265, 941, 960, 961
1266, 941, 961, 942
1267, 942, 961, 962
1268, 942, 962, 943
1269, 943, 962, 963
1270, 943, 963, 944
1271, 944, 963, 964
1272, 944, 964, 945
1273, 945, 964, 965
1274, 945, 965, 946
1275, 946, 965, 966
1276, 946, 966, 947
1277, 947, 966, 967
1278, 947, 967, 948
1279, 948, 967, 968
1280, 948, 968, 949
1281, 949, 968, 969
1282, 949, 969, 950
1283, 950, 969, 970
1284, 950, 970, 951
1285, 951, 970, 971
1286, 951, 971, 952
1287, 952, 971, 972
1288, 952, 972, 953
1289, 953, 972, 973
1290, 953, 973, 954
1291, 954, 973, 974
1292, 954, 974, 955
1293, 955, 974, 975
1294, 955, 975, 956
1295, 956, 975, 976
1296, 956, 976, 957
1297, 957, 976, 977
1298, 957, 977, 958
1299, 958, 977, 978
1300, 958, 978, 335
1301, 335, 978, 336
1302, 409, 41, 959
1303, 959, 41, 410
1304, 959, 410, 960
1305, 960, 410, 411
1306, 960, 411, 961
1307, 961, 411, 412
1308, 961, 412, 962
1309, 962, 412, 413
1310, 962, 413, 963
1311, 963, 413, 414
1312, 963, 414, 964
1313, 964, 414, 415
1314, 964, 415, 965
1315, 965, 415, 416
1316, 965, 416, 966
1317, 966, 416, 417
1318, 966, 417, 967
1319, 967, 417, 418
1320, 967, 418, 968
1321, 968, 418, 419
1322, 968, 419, 969
1323, 969, 419, 420
1324, 969, 420, 970
1325, 970, 420, 421
1326, 970, 421, 971
1327, 971, 421, 422
1328, 971, 422, 972
1329, 972, 422, 423
1330, 972, 423, 973
1331, 973, 423, 424
1332, 973, 424, 974
1333, 974, 424, 425
1334, 974, 425, 975
1335, 975, 425, 426
1336, 975, 426, 976
1337, 976, 426, 427
1338, 976, 427, 977
1339, 977, 427, 428
1340, 977, 428, 978
1341, 978, 428, 429
1342, 978, 429, 336
1343, 336, 429, 33
1344, 42, 430, 440
1345, 440, 430, 979
1346, 440, 979, 33
1347, 33, 979, 337
1348, 430, 431, 979
1349, 979, 431, 980
1350, 979, 980, 337
1351, 337, 980, 338
1352, 431, 432, 980
1353, 980, 432, 981
1354, 980, 981, 338
1355, 338, 981, 339
1356, 432, 433, 981
1357, 981, 433, 982
1358, 981, 982, 339
1359, 339, 982, 340
1360, 433, 434, 982
1361, 982, 434, 983
1362, 982, 983, 340
1363, 340, 983, 341
1364, 434, 435, 983
1365, 983, 435, 984
1366, 983, 984, 341
1367, 341, 984, 342
1368, 435, 436, 984
1369, 984, 436, 985
1370, 984, 985, 342
1371, 342, 985, 343
1372, 436, 437, 985
1373, 985, 437, 986
1374, 985, 986, 343
1375, 343, 986, 344
1376, 437, 438, 986
1377, 986, 438, 987
1378, 986, 987, 344
1379, 344, 987, 345
1380, 438, 439, 987
1381, 987, 439, 988
1382, 987, 988, 345
1383, 345, 988, 346
1384, 439, 34, 988
1385, 988, 34, 357
1386, 988, 357, 346
1387, 346, 357, 22
1388, 34, 441, 347
1389, 347, 441, 989
1390, 347, 989, 348
1391, 348, 989, 990
1392, 348, 990, 349
1393, 349, 990, 991
1394, 349, 991, 350
1395, 350, 991, 992
1396, 350, 992, 351
1397, 351, 992, 993
1398, 351, 993, 352
1399, 352, 993, 994
1400, 352, 994, 353
1401, 353, 994, 995
1402, 353, 995, 354
1403, 354, 995, 996
1404, 354, 996, 355
1405, 355, 996, 997
1406, 355, 997, 356
1407, 356, 997, 998
1408, 356, 998, 23
1409, 23, 998, 358
1410, 441, 43, 989
1411, 989, 43, 442
1412, 989, 442, 990
1413, 990, 442, 443
1414, 990, 443, 991
1415, 991, 443, 444
1416, 991, 444, 992
1417, 992, 444, 445
1418, 992, 445, 993
1419, 993, 445, 446
1420, 993, 446, 994
1421, 994, 446, 447
1422, 994, 447, 995
1423, 995, 447, 448
1424, 995, 448, 996
1425, 996, 448, 449
1426, 996, 449, 997
1427, 997, 449, 450
1428, 997, 450, 998
1429, 998, 450, 451
1430, 998, 451, 358
1431, 358, 451, 35
1432, 31, 375, 376
1433, 375, 999, 376
1434, 375, 374, 999
1435, 374, 1000, 999
1436, 374, 39, 1000
1437, 39, 452, 1000
1438, 376, 999, 40
1439, 999, 454, 40
1440, 999, 1000, 454
1441, 1000, 453, 454
1442, 1000, 452, 453
1443, 452, 44, 453
1444, 40, 455, 377
1445, 377, 455, 1001
1446, 377, 1001, 378
1447, 378, 1001, 1002
1448, 378, 1002, 379
1449, 379, 1002, 1003
1450, 379, 1003, 380
1451, 380, 1003, 1004
1452, 380, 1004, 381
1453, 381, 1004, 1005
1454, 381, 1005, 382
1455, 382, 1005, 1006
1456, 382, 1006, 383
1457, 383, 1006, 1007
1458, 383, 1007, 384
1459, 384, 1007, 1008
1460, 384, 1008, 385
1461, 385, 1008, 1009
1462, 385, 1009, 386
1463, 386, 1009, 1010
1464, 386, 1010, 387
1465, 387, 1010, 1011
1466, 387, 1011, 388
1467, 388, 1011, 1012
1468, 388, 1012, 389
1469, 389, 1012, 1013
1470, 389, 1013, 390
1471, 390, 1013, 1014
1472, 390, 1014, 391
1473, 391, 1014, 1015
1474, 391, 1015, 392
1475, 392, 1015, 1016
1476, 392, 1016, 393
1477, 393, 1016, 1017
1478, 393, 1017, 394
1479, 394, 1017, 1018
1480, 394, 1018, 395
1481, 395, 1018, 1019
1482, 395, 1019, 396
1483, 396, 1019, 1020
1484, 396, 1020, 397
1485, 397, 1020, 1021
1486, 397, 1021, 398
1487, 398, 1021, 1022
1488, 398, 1022, 399
1489, 399, 1022, 1023
1490, 399, 1023, 400
1491, 400, 1023, 1024
1492, 400, 1024, 401
1493, 401, 1024, 1025
1494, 401, 1025, 402
1495, 402, 1025, 1026
1496, 402, 1026, 403
1497, 403, 1026, 1027
1498, 403, 1027, 404
1499, 404, 1027, 1028
1500, 404, 1028, 405
1501, 405, 1028, 1029
1502, 405, 1029, 406
1503, 406, 1029, 1030
1504, 406, 1030, 407
1505, 407, 1030, 1031
1506, 407, 1031, 32
1507, 32, 1031, 408
1508, 455, 456, 1001
1509, 1001, 456, 1032
1510, 1001, 1032, 1002
1511, 1002, 1032, 1033
1512, 1002, 1033, 1003
1513, 1003, 1033, 1034
1514, 1003, 1034, 1004
1515, 1004, 1034, 1035
1516, 1004, 1035, 1005
1517, 1005, 1035, 1036
1518, 1005, 1036, 1006
1519, 1006, 1036, 1037
1520, 1006, 1037, 1007
1521, 1007, 1037, 1038
1522, 1007, 1038, 1008
1523, 1008, 1038, 1039
1524, 1008, 1039, 1009
1525, 1009, 1039, 1040
1526, 1009, 1040, 1010
1527, 1010, 1040, 1041
1528, 1010, 1041, 1011
1529, 1011, 1041, 1042
1530, 1011, 1042, 1012
1531, 1012, 1042, 1043
1532, 1012, 1043, 1013
1533, 1013, 1043, 1044
1534, 1013, 1044, 1014
1535, 1014, 1044, 1045
1536, 1014, 1045, 1015
1537, 1015, 1045, 1046
1538, 1015, 1046, 1016
1539, 1016, 1046, 1047
1540, 1016, 1047, 1017
1541, 1017, 1047, 1048
1542, 1017, 1048, 1018
1543, 1018, 1048, 1049
1544, 1018, 1049, 1019
1545, 1019, 1049, 1050
1546, 1019, 1050, 1020
1547, 1020, 1050, 1051
1548, 1020, 1051, 1021
1549, 1021, 1051, 1052
1550, 1021, 1052, 1022
1551, 1022, 1052, 1053
1552, 1022, 1053, 1023
1553, 1023, 1053, 1054
1554, 1023, 1054, 1024
1555, 1024, 1054, 1055
1556, 1024, 1055, 1025
1557, 1025, 1055, 1056
1558, 1025, 1056, 1026
1559, 1026, 1056, 1057
1560, 1026, 1057, 1027
1561, 1027, 1057, 1058
1562, 1027, 1058, 1028
1563, 1028, 1058, 1059
1564, 1028, 1059, 1029
1565, 1029, 1059, 1060
1566, 1029, 1060, 1030
1567, 1030, 1060, 1061
1568, 1030, 1061, 1031
1569, 1031, 1061, 1062
1570, 1031, 1062, 408
1571, 408, 1062, 409
1572, 456, 45, 1032
1573, 1032, 45, 457
1574, 1032, 457, 1033
1575, 1033, 457, 458
1576, 1033, 458, 1034
1577, 1034, 458, 459
1578, 1034, 459, 1035
1579, 1035, 459, 460
1580, 1035, 460, 1036
1581, 1036, 460, 461
1582, 1036, 461, 1037
1583, 1037, 461, 462
1584, 1037, 462, 1038
1585, 1038, 462, 463
1586, 1038, 463, 1039
1587, 1039, 463, 464
1588, 1039, 464, 1040
1589, 1040, 464, 465
1590, 1040, 465, 1041
1591, 1041, 465, 466
1592, 1041, 466, 1042
1593, 1042, 466, 467
1594, 1042, 467, 1043
1595, 1043, 467, 468
1596, 1043, 468, 1044
1597, 1044, 468, 469
1598, 1044, 469, 1045
1599, 1045, 469, 470
1600, 1045, 470, 1046
1601, 1046, 470, 471
1602, 1046, 471, 1047
1603, 1047, 471, 472
1604, 1047, 472, 1048
1605, 1048, 472, 473
1606, 1048, 473, 1049
1607, 1049, 473, 474
1608, 1049, 474, 1050
1609, 1050, 474, 475
1610, 1050, 475, 1051
1611, 1051, 475, 476
1612, 1051, 476, 1052
1613, 1052, 476, 477
1614, 1052, 477, 1053
1615, 1053, 477, 478
1616, 1053, 478, 1054
1617, 1054, 478, 479
1618, 1054, 479, 1055
1619, 1055, 479, 480
1620, 1055, 480, 1056
1621, 1056, 480, 481
1622, 1056, 481, 1057
1623, 1057, 481, 482
1624, 1057, 482, 1058
1625, 1058, 482, 483
1626, 1058, 483, 1059
1627, 1059, 483, 484
1628, 1059, 484, 1060
1629, 1060, 484, 485
1630, 1060, 485, 1061
1631, 1061, 485, 486
1632, 1061, 486, 1062
1633, 1062, 486, 487
1634, 1062, 487, 409
1635, 409, 487, 41
1636, 46, 488, 508
1637, 508, 488, 1063
1638, 508, 1063, 41
1639, 41, 1063, 410
1640, 488, 489, 1063
1641, 1063, 489, 1064
1642, 1063, 1064, 410
1643, 410, 1064, 411
1644, 489, 490, 1064
1645, 1064, 490, 1065
1646, 1064, 1065, 411
1647, 411, 1065, 412
1648, 490, 491, 1065
1649, 1065, 491, 1066
1650, 1065, 1066, 412
1651, 412, 1066, 413
1652, 491, 492, 1066
1653, 1066, 492, 1067
1654, 1066, 1067, 413
1655, 413, 1067, 414
1656, 492, 493, 1067
1657, 1067, 493, 1068
1658, 1067, 1068, 414
1659, 414, 1068, 415
1660, 493, 494, 1068
1661, 1068, 494, 1069
1662, 1068, 1069, 415
1663, 415, 1069, 416
1664, 494, 495, 1069
1665, 1069, 495, 1070
1666, 1069, 1070, 416
1667, 416, 1070, 417
1668, 495, 496, 1070
1669, 1070, 496, 1071
1670, 1070, 1071, 417
1671, 417, 1071, 418
1672, 496, 497, 1071
1673, 1071, 497, 1072
1674, 1071, 1072, 418
1675, 418, 1072, 419
1676, 497, 498, 1072
1677, 1072, 498, 1073
1678, 1072, 1073, 419
1679, 419, 1073, 420
1680, 498, 499, 1073
1681, 1073, 499, 1074
1682, 1073, 1074, 420
1683, 420, 1074, 421
1684, 499, 500, 1074
1685, 1074, 500, 1075
1686, 1074, 1075, 421
1687, 421, 1075, 422
1688, 500, 501, 1075
1689, 1075, 501, 1076
1690, 1075, 1076, 422
1691, 422, 1076, 423
1692, 501, 502, 1076
1693, 1076, 502, 1077
1694, 1076, 1077, 423
1695, 423, 1077, 424
1696, 502, 503, 1077
1697, 1077, 503, 1078
1698, 1077, 1078, 424
1699, 424, 1078, 425
1700, 503, 504, 1078
1701, 1078, 504, 1079
1702, 1078, 1079, 425
1703, 425, 1079, 426
1704, 504, 505, 1079
1705, 1079, 505, 1080
1706, 1079, 1080, 426
1707, 426, 1080, 427
1708, 505, 506, 1080
1709, 1080, 506, 1081
1710, 1080, 1081, 427
1711, 427, 1081, 428
1712, 506, 507, 1081
1713, 1081, 507, 1082
1714, 1081, 1082, 428
1715, 428, 1082, 429
1716, 507, 42, 1082
1717, 1082, 42, 440
1718, 1082, 440, 429
1719, 429, 440, 33
1720, 42, 509, 430
1721, 430, 509, 1083
1722, 430, 1083, 431
1723, 431, 1083, 1084
