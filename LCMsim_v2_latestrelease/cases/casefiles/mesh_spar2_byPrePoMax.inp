**
** Heading +++++++++++++++++++++++++++++++++++++++++++++++++
**
*Heading
Hash: LSwucRwv, Date: 01/03/2024, Unit system: M_KG_S_C
**
** Nodes +++++++++++++++++++++++++++++++++++++++++++++++++++
**
*Node
1, 1.30558006E+001, 2.07338173E-001, -1.39109750E+000
2, 1.30270435E+001, 2.04988604E-001, -1.39058266E+000
3, 1.29635604E+001, 1.77333621E-001, -1.58063785E+000
4, 1.29920516E+001, 1.80339432E-001, -1.58063742E+000
5, 1.31211306E+001, 2.73908222E-001, -1.21246190E+000
6, 1.30925618E+001, 2.71365254E-001, -1.21133746E+000
7, 1.30186093E+001, 1.96634228E-001, -1.38966719E+000
8, 1.29555090E+001, 1.68823541E-001, -1.58063795E+000
9, 1.29501019E+001, 1.75065304E-001, -1.62355425E+000
10, 1.29697167E+001, 1.77183110E-001, -1.62310103E+000
11, 1.29765905E+001, 1.77945262E-001, -1.61997470E+000
12, 1.29795297E+001, 1.78290609E-001, -1.61683596E+000
13, 1.29815527E+001, 1.78554025E-001, -1.61294565E+000
14, 1.31860388E+001, 3.67611857E-001, -1.04582119E+000
15, 1.31574072E+001, 3.64380791E-001, -1.04376574E+000
16, 1.30839493E+001, 2.62857318E-001, -1.20945349E+000
17, 1.30137418E+001, 1.08457428E-001, -1.38081919E+000
18, 1.29543738E+001, 7.34282088E-002, -1.58063423E+000
19, 1.29421075E+001, 1.66470601E-001, -1.62379199E+000
20, 1.33314882E+001, 5.86361578E-001, -7.39359905E-001
21, 1.33022712E+001, 5.82987977E-001, -7.35976922E-001
22, 1.31490460E+001, 3.55877838E-001, -1.04097020E+000
23, 1.30768261E+001, 1.82198060E-001, -1.19309864E+000
24, 1.30217553E+001, 9.98697367E-002, -1.38002847E+000
25, 1.29627878E+001, 6.50100514E-002, -1.58063787E+000
26, 1.29386499E+001, 1.57450026E-001, -1.63525362E+000
27, 1.29402205E+001, 1.58334822E-001, -1.63005712E+000
28, 1.29409293E+001, 1.59530394E-001, -1.62771117E+000
29, 1.29414715E+001, 1.61490511E-001, -1.62591182E+000
30, 1.29515060E+001, 7.28280078E-002, -1.59089518E+000
31, 1.29506596E+001, 7.91238358E-002, -1.59409473E+000
32, 1.29499564E+001, 8.14545312E-002, -1.59665073E+000
33, 1.29480759E+001, 8.26030591E-002, -1.60334729E+000
34, 1.29442292E+001, 8.24894793E-002, -1.61703648E+000
35, 1.29369161E+001, 8.24702582E-002, -1.64334819E+000
36, 1.29282311E+001, 8.24903222E-002, -1.67515980E+000
37, 1.29260534E+001, 8.42655839E-002, -1.68308358E+000
38, 1.29250592E+001, 8.58729220E-002, -1.68663187E+000
39, 1.29241726E+001, 8.82916089E-002, -1.68969992E+000
40, 1.29234377E+001, 9.14526500E-002, -1.69212285E+000
41, 1.29228293E+001, 9.52845443E-002, -1.69399778E+000
42, 1.29226964E+001, 1.51622363E-001, -1.68928826E+000
43, 1.29235355E+001, 1.54051011E-001, -1.68621136E+000
44, 1.29245393E+001, 1.55641684E-001, -1.68266315E+000
45, 1.29268266E+001, 1.57431946E-001, -1.67477827E+000
46, 1.29362729E+001, 1.57440354E-001, -1.64312839E+000
47, 1.36261954E+001, 9.31173110E-001, -3.39783309E-001
48, 1.35933347E+001, 9.29571165E-001, -3.36424992E-001
49, 1.32942221E+001, 5.75191160E-001, -7.31473770E-001
50, 1.31447253E+001, 2.82389642E-001, -1.01948291E+000
51, 1.30846604E+001, 1.73490746E-001, -1.19151076E+000
52, 1.30491978E+001, 9.88745797E-002, -1.38021543E+000
53, 1.29899638E+001, 6.44228664E-002, -1.58062832E+000
54, 1.29600211E+001, 6.44388335E-002, -1.59056200E+000
55, 1.36187344E+001, 9.53801957E-001, -3.10682189E-001
56, 1.35863372E+001, 9.25147719E-001, -3.28684273E-001
57, 1.32933099E+001, 5.21068326E-001, -7.03353981E-001
58, 1.31528480E+001, 2.74076180E-001, -1.01735310E+000
59, 1.31121242E+001, 1.72607866E-001, -1.19193393E+000
60, 1.29853619E+001, 6.41289440E-002, -1.58675718E+000
61, 1.29825077E+001, 6.40543113E-002, -1.58890703E+000
62, 1.29790860E+001, 6.40555973E-002, -1.59006557E+000
63, 1.29752809E+001, 6.41117876E-002, -1.59048819E+000
64, 1.36116224E+001, 9.49436296E-001, -3.02967457E-001
65, 1.35926641E+001, 9.10412831E-001, -3.03202898E-001
66, 1.33018445E+001, 5.13605643E-001, -6.99997021E-001
67, 1.31803943E+001, 2.73914059E-001, -1.01841420E+000
68, 1.36168665E+001, 9.35794951E-001, -2.80092941E-001
69, 1.36043163E+001, 9.06161313E-001, -2.96017796E-001
70, 1.33299701E+001, 5.13767477E-001, -7.01643199E-001
71, 1.36294033E+001, 9.32375661E-001, -2.72169643E-001
72, 1.36366420E+001, 9.06066151E-001, -2.96335122E-001
73, 1.36440097E+001, 9.13648958E-001, -2.89355486E-001
74, 1.30414220E+001, 2.06163388E-001, -1.39084008E+000
75, 1.30211090E+001, 2.01399718E-001, -1.40762966E+000
76, 1.30151930E+001, 1.97961099E-001, -1.42471394E+000
77, 1.30092987E+001, 1.94682233E-001, -1.44183703E+000
78, 1.30034380E+001, 1.91654737E-001, -1.45901783E+000
79, 1.29976143E+001, 1.88899485E-001, -1.47625688E+000
80, 1.29918383E+001, 1.86426001E-001, -1.49355460E+000
81, 1.29861092E+001, 1.84220491E-001, -1.51090413E+000
82, 1.29804239E+001, 1.82259781E-001, -1.52829744E+000
83, 1.29747727E+001, 1.80482883E-001, -1.54572166E+000
84, 1.29691540E+001, 1.78847753E-001, -1.56317025E+000
85, 1.29778060E+001, 1.78836527E-001, -1.58063763E+000
86, 1.29976913E+001, 1.81881111E-001, -1.56323491E+000
87, 1.30033491E+001, 1.83497980E-001, -1.54584511E+000
88, 1.30090317E+001, 1.85234840E-001, -1.52847502E+000
89, 1.30147455E+001, 1.87136464E-001, -1.51113249E+000
90, 1.30204966E+001, 1.89247557E-001, -1.49382661E+000
91, 1.30262905E+001, 1.91612648E-001, -1.47656798E+000
92, 1.30321321E+001, 1.94275918E-001, -1.45936900E+000
93, 1.30380154E+001, 1.97252339E-001, -1.44223570E+000
94, 1.30439280E+001, 2.00475067E-001, -1.42515699E+000
95, 1.30498595E+001, 2.03863679E-001, -1.40811695E+000
96, 1.31068462E+001, 2.72636738E-001, -1.21189968E+000
97, 1.30867788E+001, 2.63971136E-001, -1.22716594E+000
98, 1.30809669E+001, 2.56667596E-001, -1.24302575E+000
99, 1.30751091E+001, 2.49536361E-001, -1.25894690E+000
100, 1.30691894E+001, 2.42660233E-001, -1.27495701E+000
101, 1.30631945E+001, 2.36122606E-001, -1.29108040E+000
102, 1.30571485E+001, 2.29978158E-001, -1.30733867E+000
103, 1.30510866E+001, 2.24250896E-001, -1.32374267E+000
104, 1.30450387E+001, 2.18965310E-001, -1.34029932E+000
105, 1.30390232E+001, 2.14085906E-001, -1.35699215E+000
106, 1.30330294E+001, 2.09471028E-001, -1.37376800E+000
107, 1.30617788E+001, 2.11805076E-001, -1.37432639E+000
108, 1.30677729E+001, 2.16414015E-001, -1.35759951E+000
109, 1.30737882E+001, 2.21276140E-001, -1.34095225E+000
110, 1.30798283E+001, 2.26501386E-001, -1.32442465E+000
111, 1.30858920E+001, 2.32194156E-001, -1.30806120E+000
112, 1.30919290E+001, 2.38357784E-001, -1.29185904E+000
113, 1.30979099E+001, 2.44922863E-001, -1.27579419E+000
114, 1.31038229E+001, 2.51827732E-001, -1.25984699E+000
115, 1.31096576E+001, 2.59012174E-001, -1.24399463E+000
116, 1.31154118E+001, 2.66409770E-001, -1.22821092E+000
117, 1.30127252E+001, 1.93108255E-001, -1.40681852E+000
118, 1.30068504E+001, 1.89657162E-001, -1.42398821E+000
119, 1.30009953E+001, 1.86392310E-001, -1.44120092E+000
120, 1.29951701E+001, 1.83355956E-001, -1.45846539E+000
121, 1.29893827E+001, 1.80587613E-001, -1.47578770E+000
122, 1.29836364E+001, 1.78062607E-001, -1.49316070E+000
123, 1.29779350E+001, 1.75806435E-001, -1.51058541E+000
124, 1.29722808E+001, 1.73808130E-001, -1.52805692E+000
125, 1.29666670E+001, 1.72016242E-001, -1.54556388E+000
126, 1.29610810E+001, 1.70386452E-001, -1.56309562E+000
127, 1.29579321E+001, 1.74594761E-001, -1.58062201E+000
128, 1.30212988E+001, 2.02339494E-001, -1.39025398E+000
129, 1.29868022E+001, 1.79446729E-001, -1.59679153E+000
130, 1.29590742E+001, 1.76577516E-001, -1.59494332E+000
131, 1.29545881E+001, 1.75821410E-001, -1.60924878E+000
132, 1.31717230E+001, 3.65996324E-001, -1.04479347E+000
133, 1.31513601E+001, 3.55421438E-001, -1.05865480E+000
134, 1.31453345E+001, 3.46520851E-001, -1.07358772E+000
135, 1.31393400E+001, 3.37696875E-001, -1.08857854E+000
136, 1.31333786E+001, 3.28966865E-001, -1.10363737E+000
137, 1.31274520E+001, 3.20348693E-001, -1.11877418E+000
138, 1.31215625E+001, 3.11860448E-001, -1.13399858E+000
139, 1.31157119E+001, 3.03520418E-001, -1.14931960E+000
140, 1.31098930E+001, 2.95332541E-001, -1.16473446E+000
141, 1.31040981E+001, 2.87266198E-001, -1.18022234E+000
142, 1.30983225E+001, 2.79285432E-001, -1.19576166E+000
143, 1.31268974E+001, 2.81927503E-001, -1.19698601E+000
144, 1.31326733E+001, 2.89997028E-001, -1.18153967E+000
145, 1.31384658E+001, 2.98143867E-001, -1.16614025E+000
146, 1.31442826E+001, 3.06394881E-001, -1.15080556E+000
147, 1.31501307E+001, 3.14776623E-001, -1.13555396E+000
148, 1.31560177E+001, 3.23313754E-001, -1.12040389E+000
149, 1.31619539E+001, 3.31996282E-001, -1.10535593E+000
150, 1.31679334E+001, 3.40794368E-001, -1.09039244E+000
151, 1.31739468E+001, 3.49680854E-001, -1.07549492E+000
152, 1.31799849E+001, 3.58628892E-001, -1.06064430E+000
153, 1.30781456E+001, 2.55524725E-001, -1.22538122E+000
154, 1.30723224E+001, 2.48255409E-001, -1.24133076E+000
155, 1.30664531E+001, 2.41153869E-001, -1.25733875E+000
156, 1.30605182E+001, 2.34306854E-001, -1.27343317E+000
157, 1.30545179E+001, 2.27775440E-001, -1.28963400E+000
158, 1.30484823E+001, 2.21616318E-001, -1.30596688E+000
159, 1.30424448E+001, 2.15872742E-001, -1.32244979E+000
160, 1.30364387E+001, 2.10594709E-001, -1.33909873E+000
161, 1.30304714E+001, 2.05713447E-001, -1.35588264E+000
162, 1.30245326E+001, 2.01105677E-001, -1.37275382E+000
163, 1.30867318E+001, 2.68599476E-001, -1.21064063E+000
164, 1.30169868E+001, 1.67241961E-001, -1.38671785E+000
165, 1.30153643E+001, 1.37849694E-001, -1.38376852E+000
166, 1.30082113E+001, 1.03771398E-001, -1.39864666E+000
167, 1.30026907E+001, 9.92320549E-002, -1.41651495E+000
168, 1.29971924E+001, 9.49877058E-002, -1.43446239E+000
169, 1.29917170E+001, 9.10398030E-002, -1.45248425E+000
170, 1.29862741E+001, 8.74992443E-002, -1.47060035E+000
171, 1.29808681E+001, 8.43066469E-002, -1.48879194E+000
172, 1.29755019E+001, 8.15086541E-002, -1.50706006E+000
173, 1.29701802E+001, 7.91397492E-002, -1.52540179E+000
174, 1.29648911E+001, 7.70591633E-002, -1.54378812E+000
175, 1.29596244E+001, 7.51747222E-002, -1.56220205E+000
176, 1.29547522E+001, 1.05226653E-001, -1.58063547E+000
177, 1.29551306E+001, 1.37025097E-001, -1.58063671E+000
178, 1.29510418E+001, 1.68039227E-001, -1.59502263E+000
179, 1.29465746E+001, 1.67254914E-001, -1.60940731E+000
180, 1.29444097E+001, 1.72346079E-001, -1.62372883E+000
181, 1.31925062E+001, 3.77403071E-001, -1.03058186E+000
182, 1.31989827E+001, 3.87215277E-001, -1.01535993E+000
183, 1.32054760E+001, 3.97061211E-001, -1.00016695E+000
184, 1.32119937E+001, 4.06953535E-001, -9.85014650E-001
185, 1.32185435E+001, 4.16904820E-001, -9.69914875E-001
186, 1.32251328E+001, 4.26927516E-001, -9.54879681E-001
187, 1.32317691E+001, 4.37033907E-001, -9.39921367E-001
188, 1.32384596E+001, 4.47236079E-001, -9.25052505E-001
189, 1.32452114E+001, 4.57545878E-001, -9.10285964E-001
190, 1.32520358E+001, 4.67959236E-001, -8.95625849E-001
191, 1.32589382E+001, 4.78457329E-001, -8.81062986E-001
192, 1.32659155E+001, 4.89032031E-001, -8.66591540E-001
193, 1.32729648E+001, 4.99675337E-001, -8.52205512E-001
194, 1.32800832E+001, 5.10379351E-001, -8.37898749E-001
195, 1.32872679E+001, 5.21136277E-001, -8.23664964E-001
196, 1.32945160E+001, 5.31938413E-001, -8.09497750E-001
197, 1.33018248E+001, 5.42778143E-001, -7.95390594E-001
198, 1.33091918E+001, 5.53647928E-001, -7.81336890E-001
199, 1.33166040E+001, 5.64540148E-001, -7.67324402E-001
200, 1.33240402E+001, 5.75447171E-001, -7.53336101E-001
201, 1.33168797E+001, 5.84674778E-001, -7.37668413E-001
202, 1.32948687E+001, 5.72050012E-001, -7.50006821E-001
203, 1.32874835E+001, 5.61120030E-001, -7.64052041E-001
204, 1.32801246E+001, 5.50205952E-001, -7.78123423E-001
205, 1.32728012E+001, 5.39315757E-001, -7.92231734E-001
206, 1.32655223E+001, 5.28457508E-001, -8.06387641E-001
207, 1.32582972E+001, 5.17639369E-001, -8.20601681E-001
208, 1.32511351E+001, 5.06869630E-001, -8.34884222E-001
209, 1.32440456E+001, 4.96156727E-001, -8.49245433E-001
210, 1.32370380E+001, 4.85509253E-001, -8.63695239E-001
211, 1.32301061E+001, 4.74935514E-001, -8.78235453E-001
212, 1.32232430E+001, 4.64442851E-001, -8.92866738E-001
213, 1.32164513E+001, 4.54043263E-001, -9.07597436E-001
214, 1.32097191E+001, 4.43746106E-001, -9.22427081E-001
215, 1.32030426E+001, 4.33549410E-001, -9.37351015E-001
216, 1.31964180E+001, 4.23450998E-001, -9.52364656E-001
217, 1.31898416E+001, 4.13448613E-001, -9.67463510E-001
218, 1.31833078E+001, 4.03535740E-001, -9.82639724E-001
219, 1.31768052E+001, 3.93689198E-001, -9.97872449E-001
220, 1.31703260E+001, 3.83891967E-001, -1.01314687E+000
221, 1.31638625E+001, 3.74127906E-001, -1.02844918E+000
222, 1.31516679E+001, 3.61546461E-001, -1.04271939E+000
223, 1.31429862E+001, 3.46924415E-001, -1.05595192E+000
224, 1.31369375E+001, 3.38001645E-001, -1.07095642E+000
225, 1.31309111E+001, 3.29152291E-001, -1.08601321E+000
226, 1.31249181E+001, 3.20418574E-001, -1.10115062E+000
227, 1.31189652E+001, 3.11811060E-001, -1.11637588E+000
228, 1.31130513E+001, 3.03332740E-001, -1.13168855E+000
229, 1.31071751E+001, 2.95001449E-001, -1.14709615E+000
230, 1.31013304E+001, 2.86800425E-001, -1.16258544E+000
231, 1.30955190E+001, 2.78747889E-001, -1.17816483E+000
232, 1.30897308E+001, 2.70790649E-001, -1.19380185E+000
233, 1.30815749E+001, 2.35970899E-001, -1.20400187E+000
234, 1.30792005E+001, 2.09084479E-001, -1.19855026E+000
235, 1.30708943E+001, 1.73998920E-001, -1.20946754E+000
236, 1.30649818E+001, 1.65925047E-001, -1.22590540E+000
237, 1.30591124E+001, 1.58123703E-001, -1.24248935E+000
238, 1.30532952E+001, 1.50654417E-001, -1.25924358E+000
239, 1.30475417E+001, 1.43592515E-001, -1.27619537E+000
240, 1.30418404E+001, 1.36928276E-001, -1.29332489E+000
241, 1.30361799E+001, 1.30678755E-001, -1.31062342E+000
242, 1.30305470E+001, 1.24793557E-001, -1.32805835E+000
243, 1.30249337E+001, 1.19182812E-001, -1.34558998E+000
244, 1.30193333E+001, 1.13756839E-001, -1.36318391E+000
245, 1.30162726E+001, 9.52502952E-002, -1.39794798E+000
246, 1.30107954E+001, 9.07242172E-002, -1.41589292E+000
247, 1.30053325E+001, 8.64123319E-002, -1.43389473E+000
248, 1.29998969E+001, 8.24652300E-002, -1.45198802E+000
249, 1.29944957E+001, 7.89313861E-002, -1.47017685E+000
250, 1.29891319E+001, 7.58026395E-002, -1.48845068E+000
251, 1.29838043E+001, 7.30554357E-002, -1.50679647E+000
252, 1.29785098E+001, 7.06532264E-002, -1.52520017E+000
253, 1.29732488E+001, 6.85883227E-002, -1.54365437E+000
254, 1.29680124E+001, 6.67459672E-002, -1.56213930E+000
255, 1.29568598E+001, 6.74989727E-002, -1.58063971E+000
256, 1.30159335E+001, 1.02488178E-001, -1.38022532E+000
257, 1.29405727E+001, 8.24798688E-002, -1.63019234E+000
258, 1.29325558E+001, 8.23611937E-002, -1.65924920E+000
259, 1.29220069E+001, 1.14476216E-001, -1.69511872E+000
260, 1.29214417E+001, 1.33818887E-001, -1.69526476E+000
261, 1.29315498E+001, 1.57436150E-001, -1.65895333E+000
262, 1.36097650E+001, 9.30372137E-001, -3.38104150E-001
263, 1.35827328E+001, 9.19029456E-001, -3.47997382E-001
264, 1.35721450E+001, 9.08483001E-001, -3.59578258E-001
265, 1.35615851E+001, 8.97927161E-001, -3.71176029E-001
266, 1.35510670E+001, 8.87357346E-001, -3.82799055E-001
267, 1.35406047E+001, 8.76769037E-001, -3.94455616E-001
268, 1.35302125E+001, 8.66157815E-001, -4.06153889E-001
269, 1.35199046E+001, 8.55519384E-001, -4.17901915E-001
270, 1.35096954E+001, 8.44849601E-001, -4.29707569E-001
271, 1.34995995E+001, 8.34144503E-001, -4.41578525E-001
272, 1.34896318E+001, 8.23400338E-001, -4.53522220E-001
273, 1.34798072E+001, 8.12613598E-001, -4.65545813E-001
274, 1.34701369E+001, 8.01785205E-001, -4.77656751E-001
275, 1.34606194E+001, 7.90921507E-001, -4.89856784E-001
276, 1.34512506E+001, 7.80027156E-001, -5.02144280E-001
277, 1.34420263E+001, 7.69106721E-001, -5.14517696E-001
278, 1.34329424E+001, 7.58164693E-001, -5.26975574E-001
279, 1.34239945E+001, 7.47205486E-001, -5.39516540E-001
280, 1.34151783E+001, 7.36233443E-001, -5.52139308E-001
281, 1.34064895E+001, 7.25252834E-001, -5.64842670E-001
282, 1.33979236E+001, 7.14267866E-001, -5.77625500E-001
283, 1.33894762E+001, 7.03282686E-001, -5.90486749E-001
284, 1.33811428E+001, 6.92301384E-001, -6.03425445E-001
285, 1.33729188E+001, 6.81327997E-001, -6.16440686E-001
286, 1.33647998E+001, 6.70366519E-001, -6.29531643E-001
287, 1.33567808E+001, 6.59420608E-001, -6.42697057E-001
288, 1.33488453E+001, 6.48485594E-001, -6.55921964E-001
289, 1.33409781E+001, 6.37557805E-001, -6.69193623E-001
290, 1.33331680E+001, 6.26636197E-001, -6.82504044E-001
291, 1.33254037E+001, 6.15719636E-001, -6.95845347E-001
292, 1.33176737E+001, 6.04806922E-001, -7.09209738E-001
293, 1.33099667E+001, 5.93896799E-001, -7.22589490E-001
294, 1.33392551E+001, 5.97264519E-001, -7.25972279E-001
295, 1.33470373E+001, 6.08170649E-001, -7.12596135E-001
296, 1.33548457E+001, 6.19080215E-001, -6.99238027E-001
297, 1.33626909E+001, 6.29993429E-001, -6.85904560E-001
298, 1.33705838E+001, 6.40910450E-001, -6.72602402E-001
299, 1.33785352E+001, 6.51831371E-001, -6.59338305E-001
300, 1.33865557E+001, 6.62756205E-001, -6.46119125E-001
301, 1.33946559E+001, 6.73684871E-001, -6.32951833E-001
302, 1.34028464E+001, 6.84617174E-001, -6.19843536E-001
303, 1.34111375E+001, 6.95552797E-001, -6.06801487E-001
304, 1.34195397E+001, 7.06491280E-001, -5.93833101E-001
305, 1.34280631E+001, 7.17432010E-001, -5.80945958E-001
306, 1.34367176E+001, 7.28374203E-001, -5.68147819E-001
307, 1.34455129E+001, 7.39316538E-001, -5.55446136E-001
308, 1.34544504E+001, 7.50248690E-001, -5.42835190E-001
309, 1.34635291E+001, 7.61163029E-001, -5.30310058E-001
310, 1.34727501E+001, 7.72055135E-001, -5.17869805E-001
311, 1.34821144E+001, 7.82920565E-001, -5.05513514E-001
312, 1.34916229E+001, 7.93754864E-001, -4.93240291E-001
313, 1.35012765E+001, 8.04553551E-001, -4.81049266E-001
314, 1.35110762E+001, 8.15312123E-001, -4.68939589E-001
315, 1.35210229E+001, 8.26026053E-001, -4.56910440E-001
316, 1.35311174E+001, 8.36690786E-001, -4.44961025E-001
317, 1.35413545E+001, 8.47305056E-001, -4.33088167E-001
318, 1.35517086E+001, 8.57878644E-001, -4.21280593E-001
319, 1.35621636E+001, 8.68416664E-001, -4.09530298E-001
320, 1.35727047E+001, 8.78923861E-001, -3.97829467E-001
321, 1.35833174E+001, 8.89405141E-001, -3.86170109E-001
322, 1.35939872E+001, 8.99865537E-001, -3.74544094E-001
323, 1.36046996E+001, 9.10310183E-001, -3.62943179E-001
324, 1.36154404E+001, 9.20744288E-001, -3.51359042E-001
325, 1.32868100E+001, 5.64194372E-001, -7.45570266E-001
326, 1.32794175E+001, 5.53202054E-001, -7.59680604E-001
327, 1.32720568E+001, 5.42231213E-001, -7.73824173E-001
328, 1.32647350E+001, 5.31291732E-001, -7.88012206E-001
329, 1.32574580E+001, 5.20390892E-001, -8.02252910E-001
330, 1.32502311E+001, 5.09535013E-001, -8.16553344E-001
331, 1.32430598E+001, 4.98730249E-001, -8.30920270E-001
332, 1.32359499E+001, 4.87983033E-001, -8.45360704E-001
333, 1.32289081E+001, 4.77300469E-001, -8.59882252E-001
334, 1.32219421E+001, 4.66690679E-001, -8.74493455E-001
335, 1.32150611E+001, 4.56163359E-001, -8.89204188E-001
336, 1.32082565E+001, 4.45740560E-001, -9.04024499E-001
337, 1.32015134E+001, 4.35425754E-001, -9.18948123E-001
338, 1.31948254E+001, 4.25210802E-001, -9.33964930E-001
339, 1.31881867E+001, 4.15089034E-001, -9.49066460E-001
340, 1.31815916E+001, 4.05055061E-001, -9.64245561E-001
341, 1.31750349E+001, 3.95104669E-001, -9.79496085E-001
342, 1.31685102E+001, 3.85233981E-001, -9.94812047E-001
343, 1.31620083E+001, 3.75418036E-001, -1.01017278E+000
344, 1.31555227E+001, 3.65638212E-001, -1.02556346E+000
345, 1.32966650E+001, 5.80388929E-001, -7.34302692E-001
346, 1.31476057E+001, 3.31381772E-001, -1.03380777E+000
347, 1.31461655E+001, 3.06885707E-001, -1.02664534E+000
348, 1.31384340E+001, 2.72669027E-001, -1.03485581E+000
349, 1.31321653E+001, 2.63069180E-001, -1.05031360E+000
350, 1.31259195E+001, 2.53590679E-001, -1.06585535E+000
351, 1.31196972E+001, 2.44234095E-001, -1.08148013E+000
352, 1.31134985E+001, 2.34999990E-001, -1.09718699E+000
353, 1.31073240E+001, 2.25888922E-001, -1.11297499E+000
354, 1.31011740E+001, 2.16901438E-001, -1.12884318E+000
355, 1.30950488E+001, 2.08038080E-001, -1.14479060E+000
356, 1.30889489E+001, 1.99299381E-001, -1.16081630E+000
357, 1.30828745E+001, 1.90685868E-001, -1.17691930E+000
358, 1.30787068E+001, 1.65317547E-001, -1.20795105E+000
359, 1.30727826E+001, 1.57267512E-001, -1.22446251E+000
360, 1.30669091E+001, 1.49439985E-001, -1.24109846E+000
361, 1.30611092E+001, 1.41936497E-001, -1.25790839E+000
362, 1.30554023E+001, 1.34857854E-001, -1.27493285E+000
363, 1.30497312E+001, 1.28213301E-001, -1.29214342E+000
364, 1.30440964E+001, 1.21986272E-001, -1.30952124E+000
365, 1.30384901E+001, 1.16121642E-001, -1.32703398E+000
366, 1.30329041E+001, 1.10536777E-001, -1.34464455E+000
367, 1.30273292E+001, 1.05147705E-001, -1.36231959E+000
368, 1.30787946E+001, 1.76161118E-001, -1.19192078E+000
369, 1.30354765E+001, 9.93721582E-002, -1.38012195E+000
370, 1.30437019E+001, 9.43282707E-002, -1.39813052E+000
371, 1.30382161E+001, 8.98960808E-002, -1.41607719E+000
372, 1.30327478E+001, 8.56715637E-002, -1.43407912E+000
373, 1.30273056E+001, 8.17490586E-002, -1.45215699E+000
374, 1.30218987E+001, 7.82224170E-002, -1.47032663E+000
375, 1.30165245E+001, 7.51257907E-002, -1.48858419E+000
376, 1.30111773E+001, 7.24172081E-002, -1.50691130E+000
377, 1.30058527E+001, 7.00505079E-002, -1.52529236E+000
378, 1.30005460E+001, 6.79791520E-002, -1.54371426E+000
379, 1.29952516E+001, 6.61454164E-002, -1.56216496E+000
380, 1.29763758E+001, 6.47164589E-002, -1.58063310E+000
381, 1.29540443E+001, 6.68854398E-002, -1.59080244E+000
382, 1.36377501E+001, 9.46521165E-001, -3.22652782E-001
383, 1.36060345E+001, 9.41686561E-001, -3.23553590E-001
384, 1.35878224E+001, 9.28197587E-001, -3.33836898E-001
385, 1.35756996E+001, 9.14482854E-001, -3.40346353E-001
386, 1.35650742E+001, 9.03814184E-001, -3.52015984E-001
387, 1.35544678E+001, 8.93139505E-001, -3.63697418E-001
388, 1.35438922E+001, 8.82455083E-001, -3.75397875E-001
389, 1.35333681E+001, 8.71754424E-001, -3.87129869E-001
390, 1.35229284E+001, 8.61027324E-001, -3.98913054E-001
391, 1.35126072E+001, 8.50263628E-001, -4.10766890E-001
392, 1.35023954E+001, 8.39466454E-001, -4.22684969E-001
393, 1.34922381E+001, 8.28649842E-001, -4.34631964E-001
394, 1.34821980E+001, 8.17796055E-001, -4.46644051E-001
395, 1.34723390E+001, 8.06894129E-001, -4.58762031E-001
396, 1.34626554E+001, 7.95949178E-001, -4.70982189E-001
397, 1.34531239E+001, 7.84968924E-001, -4.83290105E-001
398, 1.34437217E+001, 7.73960141E-001, -4.95671752E-001
399, 1.34344579E+001, 7.62927916E-001, -5.08136516E-001
400, 1.34253392E+001, 7.51876925E-001, -5.20691302E-001
401, 1.34163591E+001, 7.40811700E-001, -5.33333275E-001
402, 1.34075121E+001, 7.29736562E-001, -5.46060029E-001
403, 1.33987927E+001, 7.18655611E-001, -5.58869617E-001
404, 1.33901964E+001, 7.07572822E-001, -5.71760463E-001
405, 1.33817187E+001, 6.96492057E-001, -5.84731378E-001
406, 1.33733557E+001, 6.85417128E-001, -5.97781511E-001
407, 1.33651038E+001, 6.74351827E-001, -6.10910350E-001
408, 1.33569600E+001, 6.63299979E-001, -6.24117698E-001
409, 1.33489162E+001, 6.52262708E-001, -6.37398357E-001
410, 1.33409530E+001, 6.41234784E-001, -6.50735306E-001
411, 1.33330589E+001, 6.30214880E-001, -6.64119794E-001
412, 1.33252223E+001, 6.19201805E-001, -6.77543675E-001
413, 1.33174318E+001, 6.08194268E-001, -6.90998930E-001
414, 1.33096760E+001, 5.97190926E-001, -7.04477603E-001
415, 1.33019432E+001, 5.86190370E-001, -7.17971826E-001
416, 1.32939180E+001, 5.57150216E-001, -7.22100507E-001
417, 1.32936140E+001, 5.39109271E-001, -7.12727244E-001
418, 1.32857527E+001, 5.09003624E-001, -7.17631835E-001
419, 1.32782066E+001, 4.96950434E-001, -7.31925287E-001
420, 1.32706917E+001, 4.84929665E-001, -7.46262361E-001
421, 1.32632505E+001, 4.72988140E-001, -7.60703714E-001
422, 1.32558323E+001, 4.61073019E-001, -7.75178664E-001
423, 1.32484618E+001, 4.49207335E-001, -7.89718519E-001
424, 1.32411340E+001, 4.37384141E-001, -8.04314436E-001
425, 1.32338939E+001, 4.25651442E-001, -8.19026576E-001
426, 1.32267347E+001, 4.14021378E-001, -8.33859314E-001
427, 1.32196446E+001, 4.02488532E-001, -8.48800743E-001
428, 1.32126409E+001, 3.91094003E-001, -8.63888429E-001
429, 1.32056733E+001, 3.79767169E-001, -8.79043694E-001
430, 1.31987364E+001, 3.68507356E-001, -8.94262773E-001
431, 1.31918621E+001, 3.57395078E-001, -9.09618020E-001
432, 1.31850461E+001, 3.46431453E-001, -9.25105506E-001
433, 1.31782672E+001, 3.35584087E-001, -9.40690868E-001
434, 1.31715200E+001, 3.24829564E-001, -9.56354219E-001
435, 1.31647965E+001, 3.14145425E-001, -9.72075832E-001
436, 1.31580916E+001, 3.03516829E-001, -9.87842962E-001
437, 1.31514020E+001, 2.92933897E-001, -1.00364727E+000
438, 1.31465528E+001, 2.64396986E-001, -1.03283224E+000
439, 1.31402671E+001, 2.54767973E-001, -1.04834650E+000
440, 1.31339962E+001, 2.45217874E-001, -1.06391541E+000
441, 1.31277455E+001, 2.35775704E-001, -1.07955804E+000
442, 1.31215205E+001, 2.26470819E-001, -1.09529290E+000
443, 1.31153266E+001, 2.17331864E-001, -1.11113689E+000
444, 1.31091603E+001, 2.08356549E-001, -1.12708487E+000
445, 1.31030156E+001, 1.99515006E-001, -1.14311575E+000
446, 1.30968876E+001, 1.90777155E-001, -1.15920974E+000
447, 1.30907710E+001, 1.82112604E-001, -1.17534767E+000
448, 1.31468931E+001, 2.76528127E-001, -1.01785078E+000
449, 1.30983923E+001, 1.73049306E-001, -1.19172235E+000
450, 1.31061742E+001, 1.64318595E-001, -1.20830516E+000
451, 1.31002484E+001, 1.56163275E-001, -1.22475222E+000
452, 1.30943644E+001, 1.48249357E-001, -1.24133147E+000
453, 1.30885412E+001, 1.40686687E-001, -1.25809487E+000
454, 1.30827986E+001, 1.33585073E-001, -1.27508591E+000
455, 1.30771216E+001, 1.26961716E-001, -1.29229103E+000
456, 1.30714913E+001, 1.20756680E-001, -1.30966676E+000
457, 1.30658957E+001, 1.14913015E-001, -1.32717859E+000
458, 1.30603217E+001, 1.09372589E-001, -1.34479563E+000
459, 1.30547567E+001, 1.04067656E-001, -1.36248797E+000
460, 1.36129835E+001, 9.52529128E-001, -3.08278664E-001
461, 1.35989798E+001, 9.37292007E-001, -3.15825865E-001
462, 1.35884462E+001, 9.20236089E-001, -3.20190482E-001
463, 1.35905551E+001, 9.15324460E-001, -3.11696690E-001
464, 1.35816215E+001, 8.98443905E-001, -3.14543404E-001
465, 1.35706426E+001, 8.86458979E-001, -3.25928642E-001
466, 1.35597390E+001, 8.74454835E-001, -3.37365980E-001
467, 1.35488719E+001, 8.62440704E-001, -3.48827451E-001
468, 1.35380510E+001, 8.50416321E-001, -3.60321760E-001
469, 1.35273087E+001, 8.38374265E-001, -3.71871264E-001
470, 1.35166366E+001, 8.26318068E-001, -3.83471070E-001
471, 1.35060599E+001, 8.14238924E-001, -3.95134158E-001
472, 1.34956086E+001, 8.02128945E-001, -4.06877935E-001
473, 1.34853302E+001, 7.89977530E-001, -4.18730938E-001
474, 1.34752061E+001, 7.77796268E-001, -4.30685781E-001
475, 1.34652231E+001, 7.65589595E-001, -4.42732976E-001
476, 1.34554029E+001, 7.53352028E-001, -4.54882074E-001
477, 1.34457523E+001, 7.41088718E-001, -4.67140727E-001
478, 1.34362575E+001, 7.28810184E-001, -4.79505339E-001
479, 1.34269147E+001, 7.16518979E-001, -4.91972720E-001
480, 1.34177175E+001, 7.04218668E-001, -5.04538998E-001
481, 1.34086652E+001, 6.91916169E-001, -5.17207961E-001
482, 1.33997530E+001, 6.79619177E-001, -5.29981134E-001
483, 1.33909628E+001, 6.67329188E-001, -5.42845325E-001
484, 1.33823031E+001, 6.55049957E-001, -5.55807860E-001
485, 1.33737860E+001, 6.42789109E-001, -5.68881786E-001
486, 1.33654050E+001, 6.30550709E-001, -5.82064281E-001
487, 1.33571439E+001, 6.18335521E-001, -5.95343691E-001
488, 1.33489853E+001, 6.06140725E-001, -6.08704959E-001
489, 1.33408923E+001, 5.93959243E-001, -6.22118181E-001
490, 1.33328478E+001, 5.81788060E-001, -6.35569861E-001
491, 1.33248463E+001, 5.69626438E-001, -6.49055866E-001
492, 1.33168893E+001, 5.57474612E-001, -6.62576942E-001
493, 1.33089792E+001, 5.45329104E-001, -6.76131135E-001
494, 1.33011191E+001, 5.33192355E-001, -6.89722210E-001
495, 1.32942912E+001, 5.01514745E-001, -7.14358472E-001
496, 1.32867462E+001, 4.89435762E-001, -7.28734283E-001
497, 1.32792216E+001, 4.77379771E-001, -7.43140053E-001
498, 1.32717296E+001, 4.65357952E-001, -7.57591290E-001
499, 1.32642825E+001, 4.53381624E-001, -7.72103351E-001
500, 1.32568926E+001, 4.41462280E-001, -7.86691381E-001
501, 1.32495729E+001, 4.29612764E-001, -8.01371348E-001
502, 1.32423287E+001, 4.17853121E-001, -8.16160699E-001
503, 1.32351417E+001, 4.06167690E-001, -8.31036487E-001
504, 1.32280254E+001, 3.94579033E-001, -8.46021560E-001
505, 1.32209781E+001, 3.83098532E-001, -8.61121983E-001
506, 1.32139883E+001, 3.71727377E-001, -8.76331513E-001
507, 1.32070504E+001, 3.60469364E-001, -8.91648632E-001
508, 1.32001467E+001, 3.49283989E-001, -9.07034064E-001
509, 1.31933132E+001, 3.38308192E-001, -9.22600832E-001
510, 1.31865178E+001, 3.27452672E-001, -9.38268359E-001
511, 1.31797441E+001, 3.16665162E-001, -9.53992231E-001
512, 1.31729957E+001, 3.05946922E-001, -9.69774225E-001
513, 1.31662687E+001, 2.95287959E-001, -9.85605427E-001
514, 1.31595560E+001, 2.84671840E-001, -1.00147145E+000
515, 1.32958160E+001, 5.15750869E-001, -7.00723980E-001
516, 1.31666212E+001, 2.73995120E-001, -1.01788365E+000
517, 1.31740813E+001, 2.64190832E-001, -1.03384059E+000
518, 1.31677795E+001, 2.54516601E-001, -1.04930233E+000
519, 1.31614946E+001, 2.44918917E-001, -1.06481848E+000
520, 1.31552321E+001, 2.35425591E-001, -1.08040773E+000
521, 1.31489980E+001, 2.26064767E-001, -1.09608821E+000
522, 1.31427980E+001, 2.16863741E-001, -1.11187637E+000
523, 1.31366278E+001, 2.07817880E-001, -1.12776556E+000
524, 1.31304806E+001, 1.98898021E-001, -1.14373478E+000
525, 1.31243514E+001, 1.90075641E-001, -1.15976492E+000
526, 1.31182344E+001, 1.81321927E-001, -1.17583738E+000
527, 1.36133704E+001, 9.44889181E-001, -2.95342618E-001
528, 1.36151185E+001, 9.40342066E-001, -2.87717779E-001
529, 1.36047653E+001, 9.23103891E-001, -2.91647920E-001
530, 1.35970801E+001, 9.07367578E-001, -2.97953683E-001
531, 1.35931996E+001, 8.94096212E-001, -3.07507354E-001
532, 1.35820979E+001, 8.82027208E-001, -3.19007269E-001
533, 1.35710269E+001, 8.69950031E-001, -3.30528241E-001
534, 1.35600026E+001, 8.57860475E-001, -3.42080914E-001
535, 1.35490409E+001, 8.45754432E-001, -3.53675850E-001
536, 1.35381580E+001, 8.33627916E-001, -3.65323499E-001
537, 1.35273703E+001, 8.21477129E-001, -3.77034150E-001
538, 1.35166942E+001, 8.09298460E-001, -3.88817914E-001
539, 1.35061328E+001, 7.97091995E-001, -4.00676037E-001
540, 1.34956902E+001, 7.84858016E-001, -4.12610727E-001
541, 1.34854268E+001, 7.72584157E-001, -4.24659344E-001
542, 1.34754023E+001, 7.60260607E-001, -4.36857250E-001
543, 1.34654584E+001, 7.47921922E-001, -4.49106005E-001
544, 1.34557204E+001, 7.35555014E-001, -4.61490760E-001
545, 1.34461426E+001, 7.23169959E-001, -4.73981974E-001
546, 1.34367411E+001, 7.10770821E-001, -4.86592642E-001
547, 1.34274486E+001, 6.98366834E-001, -4.99279195E-001
548, 1.34182668E+001, 6.85961484E-001, -5.12044669E-001
549, 1.34092467E+001, 6.73558317E-001, -5.24927105E-001
550, 1.34003511E+001, 6.61162411E-001, -5.37902615E-001
551, 1.33916406E+001, 6.48781526E-001, -5.51017138E-001
552, 1.33830573E+001, 6.36418404E-001, -5.64232109E-001
553, 1.33745666E+001, 6.24073285E-001, -5.77523388E-001
554, 1.33662234E+001, 6.11752815E-001, -5.90930584E-001
555, 1.33579704E+001, 5.99447846E-001, -6.04407694E-001
556, 1.33498292E+001, 5.87162316E-001, -6.17970307E-001
557, 1.33417467E+001, 5.74887243E-001, -6.31577395E-001
558, 1.33337011E+001, 5.62618854E-001, -6.45212386E-001
559, 1.33256866E+001, 5.50356175E-001, -6.58870809E-001
560, 1.33177041E+001, 5.38099456E-001, -6.72553322E-001
561, 1.33097616E+001, 5.25850261E-001, -6.86265800E-001
562, 1.33159073E+001, 5.13686560E-001, -7.00820110E-001
563, 1.33223729E+001, 5.01689579E-001, -7.15988012E-001
564, 1.33147906E+001, 4.89623566E-001, -7.30350708E-001
565, 1.33072324E+001, 4.77579723E-001, -7.44744638E-001
566, 1.32997073E+001, 4.65568417E-001, -7.59183061E-001
567, 1.32922247E+001, 4.53600123E-001, -7.73679114E-001
568, 1.32847937E+001, 4.41685457E-001, -7.88245769E-001
569, 1.32774239E+001, 4.29835209E-001, -8.02895781E-001
570, 1.32701248E+001, 4.18060364E-001, -8.17641650E-001
571, 1.32629061E+001, 4.06372120E-001, -8.32495564E-001
572, 1.32557659E+001, 3.94783783E-001, -8.47465262E-001
573, 1.32486914E+001, 3.83301982E-001, -8.62547833E-001
574, 1.32416775E+001, 3.71927375E-001, -8.77739565E-001
575, 1.32347193E+001, 3.60660555E-001, -8.93036813E-001
576, 1.32278115E+001, 3.49502065E-001, -9.08435996E-001
577, 1.32209490E+001, 3.38452398E-001, -9.23933595E-001
578, 1.32141266E+001, 3.27512003E-001, -9.39526151E-001
579, 1.32073390E+001, 3.16678263E-001, -9.55208084E-001
580, 1.32005788E+001, 3.05922242E-001, -9.70955275E-001
581, 1.31938392E+001, 2.95221862E-001, -9.86749119E-001
582, 1.31871133E+001, 2.84558656E-001, -1.00257394E+000
583, 1.36217083E+001, 9.32926107E-001, -2.74476152E-001
584, 1.36168598E+001, 9.19268487E-001, -2.84093720E-001
585, 1.36204792E+001, 9.06113732E-001, -2.96176459E-001
586, 1.36253392E+001, 8.94063277E-001, -3.07857130E-001
587, 1.36140434E+001, 8.82058357E-001, -3.19383747E-001
588, 1.36027873E+001, 8.70041640E-001, -3.30936995E-001
589, 1.35915917E+001, 8.58007198E-001, -3.42530492E-001
590, 1.35804716E+001, 8.45950904E-001, -3.54173854E-001
591, 1.35694390E+001, 8.33869745E-001, -3.65874442E-001
592, 1.35585043E+001, 8.21761218E-001, -3.77638489E-001
593, 1.35476771E+001, 8.09623280E-001, -3.89471456E-001
594, 1.35369700E+001, 7.97452936E-001, -4.01380201E-001
595, 1.35264253E+001, 7.85237911E-001, -4.13387551E-001
596, 1.35160473E+001, 7.72980893E-001, -4.25496963E-001
597, 1.35058301E+001, 7.60688153E-001, -4.37706499E-001
598, 1.34957698E+001, 7.48365098E-001, -4.50015387E-001
599, 1.34858644E+001, 7.36016518E-001, -4.62423876E-001
600, 1.34761133E+001, 7.23646760E-001, -4.74933160E-001
601, 1.34665179E+001, 7.11259876E-001, -4.87545345E-001
602, 1.34570806E+001, 6.98859749E-001, -5.00263451E-001
603, 1.34478056E+001, 6.86450651E-001, -5.13091673E-001
604, 1.34386868E+001, 6.74046737E-001, -5.26036402E-001
605, 1.34297124E+001, 6.61653621E-001, -5.39091974E-001
606, 1.34208732E+001, 6.49271582E-001, -5.52249811E-001
607, 1.34121601E+001, 6.36900781E-001, -5.65502074E-001
608, 1.34035648E+001, 6.24541273E-001, -5.78841522E-001
609, 1.33950792E+001, 6.12193018E-001, -5.92261347E-001
610, 1.33866951E+001, 5.99855896E-001, -6.05754992E-001
611, 1.33784041E+001, 5.87529656E-001, -6.19316024E-001
612, 1.33701974E+001, 5.75214005E-001, -6.32937765E-001
613, 1.33620650E+001, 5.62908423E-001, -6.46613107E-001
614, 1.33539949E+001, 5.50612286E-001, -6.60333757E-001
615, 1.33459716E+001, 5.38324582E-001, -6.74089435E-001
616, 1.33379731E+001, 5.26043857E-001, -6.87865725E-001
617, 1.36457271E+001, 9.26812961E-001, -2.77330655E-001
618, 1.36403258E+001, 9.09857555E-001, -2.92845304E-001
619, 1.30354869E+001, 2.02653129E-001, -1.40787834E+000
620, 1.30295618E+001, 1.99226235E-001, -1.42493638E+000
621, 1.30236566E+001, 1.95966462E-001, -1.44203384E+000
622, 1.30177821E+001, 1.92957249E-001, -1.45918774E+000
623, 1.30119466E+001, 1.90243833E-001, -1.47640543E+000
624, 1.30061534E+001, 1.87811989E-001, -1.49368190E+000
625, 1.30004062E+001, 1.85642760E-001, -1.51100892E+000
626, 1.29947079E+001, 1.83714954E-001, -1.52837774E+000
627, 1.29890512E+001, 1.81981043E-001, -1.54577869E+000
628, 1.29834220E+001, 1.80376508E-001, -1.56320184E+000
629, 1.31010979E+001, 2.65189027E-001, -1.22768770E+000
630, 1.30953219E+001, 2.57834085E-001, -1.24350737E+000
631, 1.30894907E+001, 2.50665046E-001, -1.25938958E+000
632, 1.30835767E+001, 2.43773663E-001, -1.27536725E+000
633, 1.30775769E+001, 2.37232617E-001, -1.29146417E+000
634, 1.30715255E+001, 2.31082747E-001, -1.30769529E+000
635, 1.30654593E+001, 2.25362119E-001, -1.32407560E+000
636, 1.30594134E+001, 2.20101256E-001, -1.34061579E+000
637, 1.30533980E+001, 2.15234788E-001, -1.35728739E+000
638, 1.30474045E+001, 2.10632922E-001, -1.37404300E+000
639, 1.30151292E+001, 1.98503619E-001, -1.40731901E+000
640, 1.30091208E+001, 1.94945872E-001, -1.42442616E+000
641, 1.30031962E+001, 1.91627683E-001, -1.44158203E+000
642, 1.29973268E+001, 1.88556836E-001, -1.45879652E+000
643, 1.29915101E+001, 1.85767446E-001, -1.47606895E+000
644, 1.29857494E+001, 1.83278154E-001, -1.49339783E+000
645, 1.29800460E+001, 1.81080365E-001, -1.51077987E+000
646, 1.29744014E+001, 1.79139375E-001, -1.52820471E+000
647, 1.29688194E+001, 1.77411530E-001, -1.54565893E+000
648, 1.29633176E+001, 1.75883782E-001, -1.56313395E+000
649, 1.29749580E+001, 1.77805712E-001, -1.61622816E+000
650, 1.29751118E+001, 1.77962482E-001, -1.60656620E+000
651, 1.29670773E+001, 1.76978613E-001, -1.61458424E+000
652, 1.29657712E+001, 1.77021884E-001, -1.60346608E+000
653, 1.29712554E+001, 1.77815006E-001, -1.59388262E+000
654, 1.29598204E+001, 1.76161578E-001, -1.61773565E+000
655, 1.31656733E+001, 3.57032723E-001, -1.05965413E+000
656, 1.31596365E+001, 3.48101918E-001, -1.07453917E+000
657, 1.31536253E+001, 3.39236539E-001, -1.08947328E+000
658, 1.31476523E+001, 3.30469007E-001, -1.10448108E+000
659, 1.31417240E+001, 3.21823340E-001, -1.11957816E+000
660, 1.31358372E+001, 3.13310154E-001, -1.13476665E+000
661, 1.31299878E+001, 3.04938592E-001, -1.15004811E+000
662, 1.31241716E+001, 2.96715741E-001, -1.16542189E+000
663, 1.31183818E+001, 2.88619070E-001, -1.18087208E+000
664, 1.31126096E+001, 2.80606825E-001, -1.19637312E+000
665, 1.30808325E+001, 2.61127925E-001, -1.22649790E+000
666, 1.30749516E+001, 2.53772852E-001, -1.24238546E+000
667, 1.30690445E+001, 2.46608875E-001, -1.25833320E+000
668, 1.30630799E+001, 2.39712358E-001, -1.27437076E+000
669, 1.30570513E+001, 2.33149852E-001, -1.29052237E+000
670, 1.30509888E+001, 2.26970563E-001, -1.30680520E+000
671, 1.30449276E+001, 2.21224679E-001, -1.32323591E+000
672, 1.30389064E+001, 2.15959253E-001, -1.33982690E+000
673, 1.30329450E+001, 2.11123686E-001, -1.35655551E+000
674, 1.30270604E+001, 2.06613254E-001, -1.37337819E+000
675, 1.30112381E+001, 1.63245230E-001, -1.40416528E+000
676, 1.30054893E+001, 1.59400024E-001, -1.42161309E+000
677, 1.29997701E+001, 1.55819160E-001, -1.43899118E+000
678, 1.29940401E+001, 1.52497589E-001, -1.45649223E+000
679, 1.29883431E+001, 1.49482022E-001, -1.47408581E+000
680, 1.29827015E+001, 1.46767012E-001, -1.49170525E+000
681, 1.29770932E+001, 1.44356506E-001, -1.50940599E+000
682, 1.29715366E+001, 1.42257074E-001, -1.52712970E+000
683, 1.29660536E+001, 1.40391302E-001, -1.54484210E+000
684, 1.29605808E+001, 1.38662137E-001, -1.56271427E+000
685, 1.30097314E+001, 1.33472103E-001, -1.40144303E+000
686, 1.30040988E+001, 1.29259113E-001, -1.41913887E+000
687, 1.29985002E+001, 1.25358676E-001, -1.43676434E+000
688, 1.29928944E+001, 1.21749961E-001, -1.45449354E+000
689, 1.29873120E+001, 1.18484462E-001, -1.47234921E+000
690, 1.29817822E+001, 1.15542023E-001, -1.49024170E+000
691, 1.29762824E+001, 1.12945129E-001, -1.50822790E+000
692, 1.29708418E+001, 1.10717743E-001, -1.52621666E+000
693, 1.29654673E+001, 1.08744770E-001, -1.54423236E+000
694, 1.29600979E+001, 1.06927078E-001, -1.56241596E+000
695, 1.29533532E+001, 1.73668946E-001, -1.59493429E+000
696, 1.29488497E+001, 1.72899430E-001, -1.60928682E+000
697, 1.31781839E+001, 3.75763517E-001, -1.02951413E+000
698, 1.31846529E+001, 3.85546831E-001, -1.01424861E+000
699, 1.31911379E+001, 3.95362408E-001, -9.99010715E-001
700, 1.31976469E+001, 4.05226318E-001, -9.83814371E-001
701, 1.32041878E+001, 4.15154517E-001, -9.68673693E-001
702, 1.32107684E+001, 4.25162757E-001, -9.53603112E-001
703, 1.32173966E+001, 4.35266772E-001, -9.38617079E-001
704, 1.32240792E+001, 4.45478179E-001, -9.23727467E-001
705, 1.32308207E+001, 4.55792387E-001, -9.08935531E-001
706, 1.32376250E+001, 4.66201241E-001, -8.94239168E-001
707, 1.32444965E+001, 4.76697088E-001, -8.79635589E-001
708, 1.32514392E+001, 4.87271797E-001, -8.65122695E-001
709, 1.32584571E+001, 4.97917476E-001, -8.50698075E-001
710, 1.32655545E+001, 5.08626030E-001, -8.36359602E-001
711, 1.32727323E+001, 5.19389146E-001, -8.22103850E-001
712, 1.32799814E+001, 5.30198873E-001, -8.07920567E-001
713, 1.32872898E+001, 5.41047436E-001, -7.93797681E-001
714, 1.32946458E+001, 5.51927153E-001, -7.79723002E-001
715, 1.33020374E+001, 5.62830190E-001, -7.65684536E-001
716, 1.33094526E+001, 5.73748621E-001, -7.51670409E-001
717, 1.30923990E+001, 2.76410581E-001, -1.19500929E+000
718, 1.30981394E+001, 2.84342887E-001, -1.17943004E+000
719, 1.31039244E+001, 2.92392694E-001, -1.16391030E+000
720, 1.31097478E+001, 3.00570281E-001, -1.14846227E+000
721, 1.31156080E+001, 3.08889922E-001, -1.13310063E+000
722, 1.31215088E+001, 3.17360052E-001, -1.11783686E+000
723, 1.31274526E+001, 3.25977406E-001, -1.10266479E+000
724, 1.31334365E+001, 3.34719583E-001, -1.08758031E+000
725, 1.31394602E+001, 3.43563893E-001, -1.07256804E+000
726, 1.31455293E+001, 3.52502693E-001, -1.05761562E+000
727, 1.30757131E+001, 2.28280957E-001, -1.22013671E+000
728, 1.30698554E+001, 2.20717316E-001, -1.23629428E+000
729, 1.30640195E+001, 2.13430927E-001, -1.25242445E+000
730, 1.30581277E+001, 2.06405093E-001, -1.26872008E+000
731, 1.30521879E+001, 1.99696832E-001, -1.28519127E+000
732, 1.30462632E+001, 1.93395800E-001, -1.30173741E+000
733, 1.30403285E+001, 1.87497880E-001, -1.31849072E+000
734, 1.30344327E+001, 1.82054754E-001, -1.33537324E+000
735, 1.30286071E+001, 1.76969811E-001, -1.35232882E+000
736, 1.30227870E+001, 1.72055910E-001, -1.36948695E+000
737, 1.30732965E+001, 2.01108470E-001, -1.21483096E+000
738, 1.30674065E+001, 1.93268695E-001, -1.23116345E+000
739, 1.30615673E+001, 1.85744296E-001, -1.24749139E+000
740, 1.30557226E+001, 1.78521939E-001, -1.26398635E+000
741, 1.30498544E+001, 1.71625176E-001, -1.28073766E+000
742, 1.30440496E+001, 1.65167245E-001, -1.29752224E+000
743, 1.30382375E+001, 1.59100188E-001, -1.31455251E+000
744, 1.30324732E+001, 1.53463078E-001, -1.33167428E+000
745, 1.30267659E+001, 1.48128654E-001, -1.34888809E+000
746, 1.30210559E+001, 1.42935960E-001, -1.36629896E+000
747, 1.30104140E+001, 9.78637790E-002, -1.39813957E+000
748, 1.30049236E+001, 9.33400050E-002, -1.41606601E+000
749, 1.29994436E+001, 8.90452585E-002, -1.43404993E+000
750, 1.29939890E+001, 8.50827780E-002, -1.45211955E+000
751, 1.29885688E+001, 8.15192336E-002, -1.47028490E+000
752, 1.29831893E+001, 7.83524454E-002, -1.48853526E+000
753, 1.29778499E+001, 7.55805068E-002, -1.50686035E+000
754, 1.29725498E+001, 7.31964033E-002, -1.52524851E+000
755, 1.29672864E+001, 7.11290054E-002, -1.54368416E+000
756, 1.29620475E+001, 6.92730670E-002, -1.56215182E+000
757, 1.29397434E+001, 1.54155981E-001, -1.63169997E+000
758, 1.29258940E+001, 8.96577455E-002, -1.68321503E+000
759, 1.29423554E+001, 9.43097773E-002, -1.62361040E+000
760, 1.29340149E+001, 1.46712150E-001, -1.65106891E+000
761, 1.29344586E+001, 9.42020912E-002, -1.65175393E+000
762, 1.29249197E+001, 1.51094186E-001, -1.68171720E+000
763, 1.29409614E+001, 1.56628909E-001, -1.62764202E+000
764, 1.29409291E+001, 1.50680997E-001, -1.62782502E+000
765, 1.29425642E+001, 1.54644662E-001, -1.62238629E+000
766, 1.29427440E+001, 1.46546787E-001, -1.62184570E+000
767, 1.29404446E+001, 1.43115221E-001, -1.62954657E+000
768, 1.29424083E+001, 1.37008618E-001, -1.62303508E+000
769, 1.29396336E+001, 1.33739522E-001, -1.63244020E+000
770, 1.29418711E+001, 1.26435574E-001, -1.62495011E+000
771, 1.29388902E+001, 1.23118863E-001, -1.63520155E+000
772, 1.29481902E+001, 1.55954522E-001, -1.60397319E+000
773, 1.29256020E+001, 1.21810672E-001, -1.68163183E+000
774, 1.29379688E+001, 1.51269438E-001, -1.63765473E+000
775, 1.29258682E+001, 1.06339256E-001, -1.68192455E+000
776, 1.29413457E+001, 1.14694066E-001, -1.62689298E+000
777, 1.29447027E+001, 1.16318048E-001, -1.61533939E+000
778, 1.29292475E+001, 1.13276155E-001, -1.66932562E+000
779, 1.29303412E+001, 1.43532081E-001, -1.66369696E+000
780, 1.29329293E+001, 1.32524407E-001, -1.65538546E+000
781, 1.29382642E+001, 1.11296201E-001, -1.63766286E+000
782, 1.29452070E+001, 1.40960584E-001, -1.61367327E+000
783, 1.29457523E+001, 9.47863744E-002, -1.61165635E+000
784, 1.29492427E+001, 8.65743388E-002, -1.59928303E+000
785, 1.29290544E+001, 9.85990170E-002, -1.67099478E+000
786, 1.29375608E+001, 1.42529967E-001, -1.63924496E+000
787, 1.29438473E+001, 1.04612208E-001, -1.61831101E+000
788, 1.29477653E+001, 1.06021657E-001, -1.60474579E+000
789, 1.29356177E+001, 1.20306423E-001, -1.64659605E+000
790, 1.29245128E+001, 9.15655361E-002, -1.68813991E+000
791, 1.29382976E+001, 9.67716838E-002, -1.63793876E+000
792, 1.29490485E+001, 1.20325376E-001, -1.60056973E+000
793, 1.29452726E+001, 1.29261958E-001, -1.61342231E+000
794, 1.29488624E+001, 1.35452335E-001, -1.60145063E+000
795, 1.29241200E+001, 1.43226683E-001, -1.68508955E+000
796, 1.29269827E+001, 1.42002733E-001, -1.67530738E+000
797, 1.29407412E+001, 1.04427695E-001, -1.62914960E+000
798, 1.29514754E+001, 8.54497882E-002, -1.59137478E+000
799, 1.29260108E+001, 9.55066007E-002, -1.68229602E+000
800, 1.29367371E+001, 1.31080464E-001, -1.64237193E+000
801, 1.29350848E+001, 1.07825311E-001, -1.64894324E+000
802, 1.29444148E+001, 1.61107530E-001, -1.61630876E+000
803, 1.29475207E+001, 8.90981818E-002, -1.60539459E+000
804, 1.29492408E+001, 9.42511481E-002, -1.59943546E+000
805, 1.29451099E+001, 1.50648018E-001, -1.61401950E+000
806, 1.29276074E+001, 8.95321149E-002, -1.67692372E+000
807, 1.29291778E+001, 1.31068946E-001, -1.66843853E+000
808, 1.29319764E+001, 1.04786459E-001, -1.66011913E+000
809, 1.29321969E+001, 1.19854663E-001, -1.65854605E+000
810, 1.29362149E+001, 1.49254192E-001, -1.64357449E+000
811, 1.29394991E+001, 1.48650319E-001, -1.63261048E+000
812, 1.29254609E+001, 1.34181242E-001, -1.68115565E+000
813, 1.29317755E+001, 9.32137672E-002, -1.66148389E+000
814, 1.29298442E+001, 8.96962729E-002, -1.66872290E+000
815, 1.29281316E+001, 1.50042180E-001, -1.67083966E+000
816, 1.29476086E+001, 1.45600828E-001, -1.60575067E+000
817, 1.29512335E+001, 1.50708033E-001, -1.59392984E+000
818, 1.35990853E+001, 9.19896122E-001, -3.49685175E-001
819, 1.35884209E+001, 9.09405579E-001, -3.61267430E-001
820, 1.35777846E+001, 8.98905095E-001, -3.72866507E-001
821, 1.35671906E+001, 8.88389760E-001, -3.84490755E-001
822, 1.35566531E+001, 8.77854736E-001, -3.96148443E-001
823, 1.35461863E+001, 8.67295287E-001, -4.07847730E-001
824, 1.35358049E+001, 8.56706802E-001, -4.19596639E-001
825, 1.35255234E+001, 8.46084827E-001, -4.31403020E-001
826, 1.35153566E+001, 8.35425132E-001, -4.43274472E-001
827, 1.35053199E+001, 8.24723922E-001, -4.55218105E-001
828, 1.34954280E+001, 8.13977178E-001, -4.67241294E-001
829, 1.34856889E+001, 8.03184209E-001, -4.79348896E-001
830, 1.34761003E+001, 7.92349956E-001, -4.91541341E-001
831, 1.34666595E+001, 7.81480089E-001, -5.03818399E-001
832, 1.34573636E+001, 7.70580244E-001, -5.16179876E-001
833, 1.34482097E+001, 7.59656007E-001, -5.28625634E-001
834, 1.34391948E+001, 7.48712914E-001, -5.41155587E-001
835, 1.34303161E+001, 7.37756429E-001, -5.53769735E-001
836, 1.34215701E+001, 7.26791537E-001, -5.66468634E-001
837, 1.34129533E+001, 7.15822926E-001, -5.79253206E-001
838, 1.34044631E+001, 7.04856389E-001, -5.92123101E-001
839, 1.33960964E+001, 6.93897400E-001, -6.05077580E-001
840, 1.33878449E+001, 6.82947543E-001, -6.18111583E-001
841, 1.33796972E+001, 6.72005868E-001, -6.31217302E-001
842, 1.33716417E+001, 6.61071364E-001, -6.44386901E-001
843, 1.33636672E+001, 6.50143716E-001, -6.57611700E-001
844, 1.33557625E+001, 6.39222374E-001, -6.70883288E-001
845, 1.33479161E+001, 6.28306410E-001, -6.84193713E-001
846, 1.33401163E+001, 6.17394790E-001, -6.97535148E-001
847, 1.33323514E+001, 6.06486415E-001, -7.10899854E-001
848, 1.33246098E+001, 5.95580134E-001, -7.24280159E-001
849, 1.32888546E+001, 5.68885463E-001, -7.49059307E-001
850, 1.32812284E+001, 5.57596162E-001, -7.63562567E-001
851, 1.32737336E+001, 5.46478708E-001, -7.77900660E-001
852, 1.32663709E+001, 5.35528457E-001, -7.92093292E-001
853, 1.32591774E+001, 5.24793823E-001, -8.06093722E-001
854, 1.32521620E+001, 5.14280183E-001, -8.19914494E-001
855, 1.32452390E+001, 5.03852158E-001, -8.33755040E-001
856, 1.32383141E+001, 4.93363778E-001, -8.47827491E-001
857, 1.32313509E+001, 4.82767348E-001, -8.62212393E-001
858, 1.32244049E+001, 4.72160225E-001, -8.76800814E-001
859, 1.32175148E+001, 4.61614001E-001, -8.91518570E-001
860, 1.32107094E+001, 4.51186192E-001, -9.06300843E-001
861, 1.32040185E+001, 4.40937779E-001, -9.21062386E-001
862, 1.31974856E+001, 4.30952596E-001, -9.35680731E-001
863, 1.31910699E+001, 4.21178094E-001, -9.50231186E-001
864, 1.31846741E+001, 4.11463068E-001, -9.64916048E-001
865, 1.31782069E+001, 4.01662613E-001, -9.79921097E-001
866, 1.31716612E+001, 3.91760238E-001, -9.95235126E-001
867, 1.31650559E+001, 3.81780960E-001, -1.01078692E+000
868, 1.31583800E+001, 3.71705462E-001, -1.02658047E+000
869, 1.31414693E+001, 3.22180652E-001, -1.04892539E+000
870, 1.31353478E+001, 3.13036228E-001, -1.06408331E+000
871, 1.31292483E+001, 3.03973990E-001, -1.07929870E+000
872, 1.31231772E+001, 2.95021090E-001, -1.09459399E+000
873, 1.31171373E+001, 2.86188444E-001, -1.10998800E+000
874, 1.31111447E+001, 2.77510303E-001, -1.12544743E+000
875, 1.31051814E+001, 2.68973230E-001, -1.14101763E+000
876, 1.30992493E+001, 2.60564490E-001, -1.15666956E+000
877, 1.30933417E+001, 2.52286650E-001, -1.17239926E+000
878, 1.30874521E+001, 2.44103478E-001, -1.18818481E+000
879, 1.31399524E+001, 2.97436924E-001, -1.04189890E+000
880, 1.31337582E+001, 2.88070779E-001, -1.05721025E+000
881, 1.31275855E+001, 2.78795184E-001, -1.07258505E+000
882, 1.31214377E+001, 2.69624953E-001, -1.08803532E+000
883, 1.31153185E+001, 2.60578931E-001, -1.10357830E+000
884, 1.31092385E+001, 2.51688187E-001, -1.11920599E+000
885, 1.31031880E+001, 2.42945297E-001, -1.13493917E+000
886, 1.30971642E+001, 2.34328956E-001, -1.15075231E+000
887, 1.30911605E+001, 2.25825946E-001, -1.16663239E+000
888, 1.30851732E+001, 2.17416699E-001, -1.18256771E+000
889, 1.30728627E+001, 1.67975725E-001, -1.20835439E+000
890, 1.30669521E+001, 1.59911494E-001, -1.22484564E+000
891, 1.30610802E+001, 1.52084019E-001, -1.24146221E+000
892, 1.30552723E+001, 1.44605920E-001, -1.25826336E+000
893, 1.30495374E+001, 1.37544171E-001, -1.27527537E+000
894, 1.30438664E+001, 1.30895778E-001, -1.29246082E+000
895, 1.30382366E+001, 1.24639661E-001, -1.30981010E+000
896, 1.30326350E+001, 1.18754655E-001, -1.32729477E+000
897, 1.30270543E+001, 1.13170408E-001, -1.34488155E+000
898, 1.30214878E+001, 1.07787068E-001, -1.36253614E+000
899, 1.30299867E+001, 9.47836572E-002, -1.39803737E+000
900, 1.30245045E+001, 9.03045466E-002, -1.41598236E+000
901, 1.30190389E+001, 8.60442178E-002, -1.43398553E+000
902, 1.30136008E+001, 8.21121721E-002, -1.45207252E+000
903, 1.30081961E+001, 7.85754120E-002, -1.47025535E+000
904, 1.30028273E+001, 7.54366837E-002, -1.48851580E+000
905, 1.29974895E+001, 7.26900768E-002, -1.50685134E+000
906, 1.29921805E+001, 7.03271801E-002, -1.52524611E+000
907, 1.29868976E+001, 6.82809138E-002, -1.54368332E+000
908, 1.29816321E+001, 6.64458060E-002, -1.56215194E+000
909, 1.36218932E+001, 9.44097115E-001, -3.23097697E-001
910, 1.33043370E+001, 5.91335309E-001, -7.20881781E-001
911, 1.33120386E+001, 6.02269323E-001, -7.07465421E-001
912, 1.33197644E+001, 6.13207202E-001, -6.94064782E-001
913, 1.33275253E+001, 6.24149801E-001, -6.80687798E-001
914, 1.33353327E+001, 6.35098041E-001, -6.67342476E-001
915, 1.33431976E+001, 6.46052877E-001, -6.54036899E-001
916, 1.33511315E+001, 6.57015459E-001, -6.40779109E-001
917, 1.33591458E+001, 6.67986983E-001, -6.27577217E-001
918, 1.33672515E+001, 6.78968060E-001, -6.14439778E-001
919, 1.33754596E+001, 6.89959595E-001, -6.01374550E-001
920, 1.33837810E+001, 7.00962491E-001, -5.88388899E-001
921, 1.33922236E+001, 7.11975033E-001, -5.75487506E-001
922, 1.34007904E+001, 7.22992069E-001, -5.62670623E-001
923, 1.34094846E+001, 7.34008419E-001, -5.49938277E-001
924, 1.34183091E+001, 7.45018675E-001, -5.37290980E-001
925, 1.34272672E+001, 7.56017815E-001, -5.24728885E-001
926, 1.34363634E+001, 7.67002076E-001, -5.12250722E-001
927, 1.34456003E+001, 7.77965677E-001, -4.99857362E-001
928, 1.34549788E+001, 7.88900840E-001, -4.87551591E-001
929, 1.34645036E+001, 7.99804011E-001, -4.75331481E-001
930, 1.34741772E+001, 8.10669455E-001, -4.63198088E-001
931, 1.34840029E+001, 8.21493152E-001, -4.51150713E-001
932, 1.34939724E+001, 8.32275235E-001, -4.39184826E-001
933, 1.35040709E+001, 8.43019396E-001, -4.27292101E-001
934, 1.35142838E+001, 8.53729554E-001, -4.15464406E-001
935, 1.35245976E+001, 8.64410448E-001, -4.03694066E-001
936, 1.35349985E+001, 8.75066896E-001, -3.91973287E-001
937, 1.35454732E+001, 8.85703690E-001, -3.80294021E-001
938, 1.35560081E+001, 8.96325804E-001, -3.68648112E-001
939, 1.35665906E+001, 9.06938645E-001, -3.57027453E-001
940, 1.35772086E+001, 9.17548234E-001, -3.45424093E-001
941, 1.32864442E+001, 5.45708472E-001, -7.36284049E-001
942, 1.32789910E+001, 5.34294735E-001, -7.50478369E-001
943, 1.32715621E+001, 5.22931494E-001, -7.64708382E-001
944, 1.32641696E+001, 5.11640799E-001, -7.78981008E-001
945, 1.32568340E+001, 5.00422954E-001, -7.93274520E-001
946, 1.32495664E+001, 4.89286128E-001, -8.07609159E-001
947, 1.32423565E+001, 4.78187908E-001, -8.22042574E-001
948, 1.32352136E+001, 4.67137821E-001, -8.36589801E-001
949, 1.32281525E+001, 4.56166260E-001, -8.51218124E-001
950, 1.32211463E+001, 4.45247215E-001, -8.65976338E-001
951, 1.32142487E+001, 4.34492129E-001, -8.80753001E-001
952, 1.32073924E+001, 4.23796314E-001, -8.95676945E-001
953, 1.32005967E+001, 4.13200163E-001, -9.10692270E-001
954, 1.31938456E+001, 4.02703535E-001, -9.25830860E-001
955, 1.31871563E+001, 3.92332246E-001, -9.41042625E-001
956, 1.31805263E+001, 3.82073016E-001, -9.56306510E-001
957, 1.31739210E+001, 3.71872724E-001, -9.71668477E-001
958, 1.31673243E+001, 3.61706955E-001, -9.87132789E-001
959, 1.31607415E+001, 3.51575744E-001, -1.00265491E+000
960, 1.31541709E+001, 3.41471544E-001, -1.01821449E+000
961, 1.32860943E+001, 5.27316463E-001, -7.26972560E-001
962, 1.32785998E+001, 5.15550266E-001, -7.41229529E-001
963, 1.32711296E+001, 5.03833757E-001, -7.55528060E-001
964, 1.32636920E+001, 4.92203928E-001, -7.69885335E-001
965, 1.32562994E+001, 4.80625851E-001, -7.84278548E-001
966, 1.32489896E+001, 4.69157242E-001, -7.98681813E-001
967, 1.32417396E+001, 4.57727986E-001, -8.13182776E-001
968, 1.32345521E+001, 4.46354341E-001, -8.27817810E-001
969, 1.32274416E+001, 4.35069575E-001, -8.42547739E-001
970, 1.32203615E+001, 4.23811482E-001, -8.57460258E-001
971, 1.32134350E+001, 4.12808378E-001, -8.72304587E-001
972, 1.32065231E+001, 4.01809635E-001, -8.87345660E-001
973, 1.31996729E+001, 3.90899332E-001, -9.02462167E-001
974, 1.31928614E+001, 3.80102417E-001, -9.17717439E-001
975, 1.31861151E+001, 3.69455970E-001, -9.33048566E-001
976, 1.31794306E+001, 3.58934417E-001, -9.48430985E-001
977, 1.31727531E+001, 3.48449446E-001, -9.63948358E-001
978, 1.31660860E+001, 3.38004546E-001, -9.79555686E-001
979, 1.31594345E+001, 3.27601290E-001, -9.95213964E-001
980, 1.31527965E+001, 3.17232715E-001, -1.01090958E+000
981, 1.31405932E+001, 2.66865677E-001, -1.03331868E+000
982, 1.31343080E+001, 2.57239722E-001, -1.04881285E+000
983, 1.31280404E+001, 2.47698914E-001, -1.06436423E+000
984, 1.31217983E+001, 2.38284535E-001, -1.08000282E+000
985, 1.31155861E+001, 2.29021146E-001, -1.09574499E+000
986, 1.31094020E+001, 2.19907208E-001, -1.11158619E+000
987, 1.31032438E+001, 2.10938766E-001, -1.12752036E+000
988, 1.30971091E+001, 2.02110192E-001, -1.14354058E+000
989, 1.30909932E+001, 1.93396190E-001, -1.15963006E+000
990, 1.30848898E+001, 1.84758726E-001, -1.17576577E+000
991, 1.30948295E+001, 1.64718903E-001, -1.20815638E+000
992, 1.30895146E+001, 1.56577568E-001, -1.22463483E+000
993, 1.30836215E+001, 1.48699086E-001, -1.24123634E+000
994, 1.30775583E+001, 1.41195454E-001, -1.25802998E+000
995, 1.30714799E+001, 1.34133550E-001, -1.27504266E+000
996, 1.30654282E+001, 1.27500578E-001, -1.29224720E+000
997, 1.30594067E+001, 1.21275597E-001, -1.30961714E+000
998, 1.30534065E+001, 1.15435153E-001, -1.32712304E+000
999, 1.30474211E+001, 1.09907053E-001, -1.34473205E+000
1000, 1.30414461E+001, 1.04587433E-001, -1.36240990E+000
1001, 1.29688484E+001, 6.45880875E-002, -1.58517570E+000
1002, 1.29820051E+001, 6.42963368E-002, -1.58527732E+000
1003, 1.29769085E+001, 6.43723061E-002, -1.58581760E+000
1004, 1.36003121E+001, 9.40359852E-001, -3.21038691E-001
1005, 1.35776583E+001, 9.09084552E-001, -3.31731352E-001
1006, 1.35669069E+001, 8.97927700E-001, -3.43292705E-001
1007, 1.35561962E+001, 8.86753621E-001, -3.54881121E-001
1008, 1.35455143E+001, 8.75533189E-001, -3.66517007E-001
1009, 1.35348756E+001, 8.64281242E-001, -3.78199267E-001
1010, 1.35242951E+001, 8.53018745E-001, -3.89934339E-001
1011, 1.35138235E+001, 8.41795733E-001, -4.01698860E-001
1012, 1.35035730E+001, 8.30714450E-001, -4.13413379E-001
1013, 1.34934058E+001, 8.19573453E-001, -4.25260751E-001
1014, 1.34832474E+001, 8.08250700E-001, -4.37330285E-001
1015, 1.34732790E+001, 7.96942284E-001, -4.49422585E-001
1016, 1.34635055E+001, 7.85647570E-001, -4.61557351E-001
1017, 1.34538709E+001, 7.74299846E-001, -4.73809090E-001
1018, 1.34444019E+001, 7.62937730E-001, -4.86133059E-001
1019, 1.34350449E+001, 7.51510380E-001, -4.98592592E-001
1020, 1.34258452E+001, 7.40082762E-001, -5.11126286E-001
1021, 1.34168040E+001, 7.28663572E-001, -5.23727433E-001
1022, 1.34078891E+001, 7.17222492E-001, -5.36434312E-001
1023, 1.33991055E+001, 7.05776369E-001, -5.49234258E-001
1024, 1.33904595E+001, 6.94334762E-001, -5.62113910E-001
1025, 1.33819523E+001, 6.82903183E-001, -5.75067297E-001
1026, 1.33735351E+001, 6.71439698E-001, -5.88159347E-001
1027, 1.33651899E+001, 6.59948717E-001, -6.01399443E-001
1028, 1.33570507E+001, 6.48615391E-001, -6.14558188E-001
1029, 1.33490429E+001, 6.37318294E-001, -6.27732048E-001
1030, 1.33410282E+001, 6.25871731E-001, -6.41102748E-001
1031, 1.33330525E+001, 6.14377953E-001, -6.54551973E-001
1032, 1.33251308E+001, 6.02888136E-001, -6.68030725E-001
1033, 1.33172618E+001, 5.91421255E-001, -6.81528603E-001
1034, 1.33094497E+001, 5.79991844E-001, -6.95027436E-001
1035, 1.33016713E+001, 5.68569915E-001, -7.08552033E-001
1036, 1.35796339E+001, 9.03740054E-001, -3.23132288E-001
1037, 1.35687648E+001, 8.92148051E-001, -3.34599227E-001
1038, 1.35579498E+001, 8.80540201E-001, -3.46101832E-001
1039, 1.35471769E+001, 8.68891945E-001, -3.57649870E-001
1040, 1.35364436E+001, 8.57206486E-001, -3.69250088E-001
1041, 1.35257617E+001, 8.45507251E-001, -3.80901696E-001
1042, 1.35151383E+001, 8.33797280E-001, -3.92620706E-001
1043, 1.35047248E+001, 8.22222454E-001, -4.04293177E-001
1044, 1.34945164E+001, 8.10722246E-001, -4.15993673E-001
1045, 1.34842912E+001, 7.98997686E-001, -4.27985840E-001
1046, 1.34742109E+001, 7.87240483E-001, -4.40051017E-001
1047, 1.34643383E+001, 7.75516701E-001, -4.52140053E-001
1048, 1.34546245E+001, 7.63754311E-001, -4.64337926E-001
1049, 1.34450704E+001, 7.51966007E-001, -4.76633428E-001
1050, 1.34356485E+001, 7.40137096E-001, -4.89047173E-001
1051, 1.34263795E+001, 7.28300689E-001, -5.01549419E-001
1052, 1.34172654E+001, 7.16464315E-001, -5.14134641E-001
1053, 1.34082854E+001, 7.04615124E-001, -5.26824195E-001
1054, 1.33994419E+001, 6.92769467E-001, -5.39607998E-001
1055, 1.33907394E+001, 6.80927535E-001, -5.52479029E-001
1056, 1.33821768E+001, 6.69093395E-001, -5.65436471E-001
1057, 1.33736794E+001, 6.57206157E-001, -5.78571623E-001
1058, 1.33652924E+001, 6.45357941E-001, -5.91792696E-001
1059, 1.33571580E+001, 6.33708891E-001, -6.04886630E-001
1060, 1.33490801E+001, 6.21966002E-001, -6.18137413E-001
1061, 1.33409919E+001, 6.10080559E-001, -6.31581095E-001
1062, 1.33329668E+001, 5.98203315E-001, -6.45049425E-001
1063, 1.33249922E+001, 5.86338220E-001, -6.58545184E-001
1064, 1.33170738E+001, 5.74503090E-001, -6.72056260E-001
1065, 1.33092147E+001, 5.62700467E-001, -6.85576901E-001
1066, 1.33013957E+001, 5.50901833E-001, -6.99134901E-001
1067, 1.32881261E+001, 5.03742853E-001, -7.15133260E-001
1068, 1.32805887E+001, 4.91671481E-001, -7.29493574E-001
1069, 1.32730708E+001, 4.79626286E-001, -7.43884605E-001
1070, 1.32655822E+001, 4.67618863E-001, -7.58322526E-001
1071, 1.32581374E+001, 4.55656405E-001, -7.72822017E-001
1072, 1.32507494E+001, 4.43750162E-001, -7.87396392E-001
1073, 1.32434303E+001, 4.31911559E-001, -8.02060028E-001
1074, 1.32361862E+001, 4.20154483E-001, -8.16825680E-001
1075, 1.32290123E+001, 4.08486124E-001, -8.31700214E-001
1076, 1.32219044E+001, 3.96912339E-001, -8.46685402E-001
1077, 1.32148654E+001, 3.85450460E-001, -8.61767839E-001
1078, 1.32078876E+001, 3.74093545E-001, -8.76961589E-001
1079, 1.32009680E+001, 3.62850557E-001, -8.92265155E-001
1080, 1.31940973E+001, 3.51731659E-001, -9.07682402E-001
1081, 1.31872706E+001, 3.40740338E-001, -9.23211343E-001
1082, 1.31804827E+001, 3.29864206E-001, -9.38836062E-001
1083, 1.31737264E+001, 3.19083714E-001, -9.54541472E-001
1084, 1.31669954E+001, 3.08379035E-001, -9.70312028E-001
1085, 1.31602835E+001, 2.97731933E-001, -9.86130874E-001
1086, 1.31535832E+001, 2.87123758E-001, -1.00198257E+000
1087, 1.31607239E+001, 2.64270921E-001, -1.03333441E+000
1088, 1.31548349E+001, 2.54588113E-001, -1.04881509E+000
1089, 1.31489617E+001, 2.44988077E-001, -1.06435480E+000
1090, 1.31431117E+001, 2.35512433E-001, -1.07998208E+000
1091, 1.31372857E+001, 2.26185911E-001, -1.09571195E+000
1092, 1.31314727E+001, 2.17006744E-001, -1.11153892E+000
1093, 1.31256469E+001, 2.07970758E-001, -1.12745633E+000
1094, 1.31197485E+001, 1.99073427E-001, -1.14345583E+000
1095, 1.31136276E+001, 1.90294741E-001, -1.15951841E+000
1096, 1.31068945E+001, 1.81611702E-001, -1.17561624E+000
1097, 1.36008138E+001, 9.32526151E-001, -3.07776828E-001
1098, 1.36027216E+001, 9.27772915E-001, -2.99736514E-001
1099, 1.33035735E+001, 5.28033288E-001, -6.87096510E-001
1100, 1.33114835E+001, 5.40239367E-001, -6.73417849E-001
1101, 1.33194175E+001, 5.52451831E-001, -6.59757425E-001
1102, 1.33273869E+001, 5.64672864E-001, -6.46125316E-001
1103, 1.33354031E+001, 5.76904238E-001, -6.32531956E-001
1104, 1.33434795E+001, 5.89148982E-001, -6.18985403E-001
1105, 1.33516287E+001, 6.01407203E-001, -6.05495800E-001
1106, 1.33598639E+001, 6.13679417E-001, -5.92072644E-001
1107, 1.33681976E+001, 6.25969261E-001, -5.78724511E-001
1108, 1.33766412E+001, 6.38276989E-001, -5.65462423E-001
1109, 1.33852056E+001, 6.50605353E-001, -5.52296640E-001
1110, 1.33939005E+001, 6.62952736E-001, -5.39232779E-001
1111, 1.34027318E+001, 6.75312664E-001, -5.26270966E-001
1112, 1.34117015E+001, 6.87680724E-001, -5.13412229E-001
1113, 1.34208129E+001, 7.00052596E-001, -5.00656822E-001
1114, 1.34300682E+001, 7.12424889E-001, -4.88005337E-001
1115, 1.34394711E+001, 7.24792038E-001, -4.75458288E-001
1116, 1.34490266E+001, 7.37146283E-001, -4.63015899E-001
1117, 1.34587400E+001, 7.49482932E-001, -4.50677128E-001
1118, 1.34686143E+001, 7.61794054E-001, -4.38443884E-001
1119, 1.34786516E+001, 7.74075881E-001, -4.26317135E-001
1120, 1.34888567E+001, 7.86319440E-001, -4.14296591E-001
1121, 1.34992212E+001, 7.98526652E-001, -4.02375542E-001
1122, 1.35097263E+001, 8.10700807E-001, -3.90546320E-001
1123, 1.35203598E+001, 8.22849461E-001, -3.78795034E-001
1124, 1.35311027E+001, 8.34971142E-001, -3.67115586E-001
1125, 1.35419408E+001, 8.47070491E-001, -3.55496340E-001
1126, 1.35528592E+001, 8.59151019E-001, -3.43926758E-001
1127, 1.35638430E+001, 8.71216097E-001, -3.32396068E-001
1128, 1.35748783E+001, 8.83269524E-001, -3.20892923E-001
1129, 1.35859516E+001, 8.95315358E-001, -3.09405485E-001
1130, 1.33083307E+001, 5.01601919E-001, -7.15172173E-001
1131, 1.33007641E+001, 4.89528712E-001, -7.29538808E-001
1132, 1.32932189E+001, 4.77477923E-001, -7.43935370E-001
1133, 1.32857069E+001, 4.65460598E-001, -7.58377092E-001
1134, 1.32782398E+001, 4.53487750E-001, -7.72879252E-001
1135, 1.32708278E+001, 4.41567963E-001, -7.87460135E-001
1136, 1.32634838E+001, 4.29714108E-001, -8.02132866E-001
1137, 1.32562230E+001, 4.17950377E-001, -8.16892886E-001
1138, 1.32490239E+001, 4.06267496E-001, -8.31764572E-001
1139, 1.32418963E+001, 3.94680380E-001, -8.46740134E-001
1140, 1.32348339E+001, 3.83190509E-001, -8.61828443E-001
1141, 1.32278313E+001, 3.71809992E-001, -8.77024263E-001
1142, 1.32208822E+001, 3.60544610E-001, -8.92330774E-001
1143, 1.32139766E+001, 3.49404747E-001, -9.07744577E-001
1144, 1.32071286E+001, 3.38386480E-001, -9.23274919E-001
1145, 1.32003211E+001, 3.27481819E-001, -9.38899032E-001
1146, 1.31935429E+001, 3.16674393E-001, -9.54597177E-001
1147, 1.31867870E+001, 3.05936518E-001, -9.70366759E-001
1148, 1.31800539E+001, 2.95258071E-001, -9.86179354E-001
1149, 1.31733346E+001, 2.84617059E-001, -1.00202382E+000
1150, 1.36091968E+001, 9.20081442E-001, -2.86243937E-001
1151, 1.36092687E+001, 8.94105614E-001, -3.07708619E-001
1152, 1.35980703E+001, 8.82069846E-001, -3.19223593E-001
1153, 1.35869068E+001, 8.70023495E-001, -3.30761365E-001
1154, 1.35757967E+001, 8.57960870E-001, -3.42333880E-001
1155, 1.35647559E+001, 8.45878529E-001, -3.53950874E-001
1156, 1.35537966E+001, 8.33770981E-001, -3.65624006E-001
1157, 1.35429412E+001, 8.21645557E-001, -3.77352469E-001
1158, 1.35321655E+001, 8.09458750E-001, -3.89184665E-001
1159, 1.35215525E+001, 7.97293879E-001, -4.01045492E-001
1160, 1.35110577E+001, 7.85069986E-001, -4.13020169E-001
1161, 1.35007381E+001, 7.72803656E-001, -4.25099811E-001
1162, 1.34906130E+001, 7.60490559E-001, -4.37295413E-001
1163, 1.34806136E+001, 7.48160345E-001, -4.49579115E-001
1164, 1.34707841E+001, 7.35790466E-001, -4.61981817E-001
1165, 1.34611273E+001, 7.23419186E-001, -4.74469601E-001
1166, 1.34516280E+001, 7.11021434E-001, -4.87073765E-001
1167, 1.34422636E+001, 6.98618770E-001, -4.99776311E-001
1168, 1.34330369E+001, 6.86216718E-001, -5.12577284E-001
1169, 1.34239656E+001, 6.73810124E-001, -5.25489194E-001
1170, 1.34150321E+001, 6.61411631E-001, -5.38503555E-001
1171, 1.34062567E+001, 6.49020670E-001, -5.51628387E-001
1172, 1.33976080E+001, 6.36647621E-001, -5.64855927E-001
1173, 1.33890672E+001, 6.24297946E-001, -5.78174387E-001
1174, 1.33806461E+001, 6.11952396E-001, -5.91595194E-001
1175, 1.33723336E+001, 5.99640371E-001, -6.05073398E-001
1176, 1.33641178E+001, 5.87333363E-001, -6.18629488E-001
1177, 1.33559714E+001, 5.75035100E-001, -6.32246522E-001
1178, 1.33478838E+001, 5.62754413E-001, -6.45902555E-001
1179, 1.33398421E+001, 5.50481936E-001, -6.59596397E-001
1180, 1.33318341E+001, 5.38204557E-001, -6.73331406E-001
1181, 1.33238712E+001, 5.25955976E-001, -6.87058060E-001
1182, 1.36305862E+001, 9.15707625E-001, -2.87436176E-001
**
** Elements ++++++++++++++++++++++++++++++++++++++++++++++++
**
*Element, Type=S3, Elset=Shell_part-1
1, 1, 74, 95
2, 95, 74, 619
3, 95, 619, 94
4, 94, 619, 620
5, 94, 620, 93
6, 93, 620, 621
7, 93, 621, 92
8, 92, 621, 622
9, 92, 622, 91
10, 91, 622, 623
11, 91, 623, 90
12, 90, 623, 624
13, 90, 624, 89
14, 89, 624, 625
15, 89, 625, 88
16, 88, 625, 626
17, 88, 626, 87
18, 87, 626, 627
19, 87, 627, 86
20, 86, 627, 628
21, 86, 628, 4
22, 4, 628, 85
23, 74, 2, 619
24, 619, 2, 75
25, 619, 75, 620
26, 620, 75, 76
27, 620, 76, 621
28, 621, 76, 77
29, 621, 77, 622
30, 622, 77, 78
31, 622, 78, 623
32, 623, 78, 79
33, 623, 79, 624
34, 624, 79, 80
35, 624, 80, 625
36, 625, 80, 81
37, 625, 81, 626
38, 626, 81, 82
39, 626, 82, 627
40, 627, 82, 83
41, 627, 83, 628
42, 628, 83, 84
43, 628, 84, 85
44, 85, 84, 3
45, 5, 96, 116
46, 116, 96, 629
47, 116, 629, 115
48, 115, 629, 630
49, 115, 630, 114
50, 114, 630, 631
51, 114, 631, 113
52, 113, 631, 632
53, 113, 632, 112
54, 112, 632, 633
55, 112, 633, 111
56, 111, 633, 634
57, 111, 634, 110
58, 110, 634, 635
59, 110, 635, 109
60, 109, 635, 636
61, 109, 636, 108
62, 108, 636, 637
63, 108, 637, 107
64, 107, 637, 638
65, 107, 638, 1
66, 1, 638, 74
67, 96, 6, 629
68, 629, 6, 97
69, 629, 97, 630
70, 630, 97, 98
71, 630, 98, 631
72, 631, 98, 99
73, 631, 99, 632
74, 632, 99, 100
75, 632, 100, 633
76, 633, 100, 101
77, 633, 101, 634
78, 634, 101, 102
79, 634, 102, 635
80, 635, 102, 103
81, 635, 103, 636
82, 636, 103, 104
83, 636, 104, 637
84, 637, 104, 105
85, 637, 105, 638
86, 638, 105, 106
87, 638, 106, 74
88, 74, 106, 2
89, 7, 117, 128
90, 128, 117, 639
91, 128, 639, 2
92, 2, 639, 75
93, 117, 118, 639
94, 639, 118, 640
95, 639, 640, 75
96, 75, 640, 76
97, 118, 119, 640
98, 640, 119, 641
99, 640, 641, 76
100, 76, 641, 77
101, 119, 120, 641
102, 641, 120, 642
103, 641, 642, 77
104, 77, 642, 78
105, 120, 121, 642
106, 642, 121, 643
107, 642, 643, 78
108, 78, 643, 79
109, 121, 122, 643
110, 643, 122, 644
111, 643, 644, 79
112, 79, 644, 80
113, 122, 123, 644
114, 644, 123, 645
115, 644, 645, 80
116, 80, 645, 81
117, 123, 124, 645
118, 645, 124, 646
119, 645, 646, 81
120, 81, 646, 82
121, 124, 125, 646
122, 646, 125, 647
123, 646, 647, 82
124, 82, 647, 83
125, 125, 126, 647
126, 647, 126, 648
127, 647, 648, 83
128, 83, 648, 84
129, 126, 8, 648
130, 648, 8, 127
131, 648, 127, 84
132, 84, 127, 3
133, 11, 649, 10
134, 650, 653, 652
135, 129, 653, 650
136, 85, 129, 4
137, 85, 653, 129
138, 650, 651, 649
139, 3, 653, 85
140, 130, 653, 3
141, 651, 652, 131
142, 651, 654, 10
143, 649, 651, 10
144, 650, 652, 651
145, 13, 649, 12
146, 652, 653, 130
147, 131, 652, 130
148, 131, 654, 651
149, 9, 654, 131
150, 12, 649, 11
151, 13, 650, 649
152, 10, 654, 9
153, 129, 650, 13
154, 14, 132, 152
155, 152, 132, 655
156, 152, 655, 151
157, 151, 655, 656
158, 151, 656, 150
159, 150, 656, 657
160, 150, 657, 149
161, 149, 657, 658
162, 149, 658, 148
163, 148, 658, 659
164, 148, 659, 147
165, 147, 659, 660
166, 147, 660, 146
167, 146, 660, 661
168, 146, 661, 145
169, 145, 661, 662
170, 145, 662, 144
171, 144, 662, 663
172, 144, 663, 143
173, 143, 663, 664
174, 143, 664, 5
175, 5, 664, 96
176, 132, 15, 655
177, 655, 15, 133
178, 655, 133, 656
179, 656, 133, 134
180, 656, 134, 657
181, 657, 134, 135
182, 657, 135, 658
183, 658, 135, 136
184, 658, 136, 659
185, 659, 136, 137
186, 659, 137, 660
187, 660, 137, 138
188, 660, 138, 661
189, 661, 138, 139
190, 661, 139, 662
191, 662, 139, 140
192, 662, 140, 663
193, 663, 140, 141
194, 663, 141, 664
195, 664, 141, 142
196, 664, 142, 96
197, 96, 142, 6
198, 16, 153, 163
199, 163, 153, 665
200, 163, 665, 6
201, 6, 665, 97
202, 153, 154, 665
203, 665, 154, 666
204, 665, 666, 97
205, 97, 666, 98
206, 154, 155, 666
207, 666, 155, 667
208, 666, 667, 98
209, 98, 667, 99
210, 155, 156, 667
211, 667, 156, 668
212, 667, 668, 99
213, 99, 668, 100
214, 156, 157, 668
215, 668, 157, 669
216, 668, 669, 100
217, 100, 669, 101
218, 157, 158, 669
219, 669, 158, 670
220, 669, 670, 101
221, 101, 670, 102
222, 158, 159, 670
223, 670, 159, 671
224, 670, 671, 102
225, 102, 671, 103
226, 159, 160, 671
227, 671, 160, 672
228, 671, 672, 103
229, 103, 672, 104
230, 160, 161, 672
231, 672, 161, 673
232, 672, 673, 104
233, 104, 673, 105
234, 161, 162, 673
235, 673, 162, 674
236, 673, 674, 105
237, 105, 674, 106
238, 162, 7, 674
239, 674, 7, 128
240, 674, 128, 106
241, 106, 128, 2
242, 7, 164, 117
243, 117, 164, 675
244, 117, 675, 118
245, 118, 675, 676
246, 118, 676, 119
247, 119, 676, 677
248, 119, 677, 120
249, 120, 677, 678
250, 120, 678, 121
251, 121, 678, 679
252, 121, 679, 122
253, 122, 679, 680
254, 122, 680, 123
255, 123, 680, 681
256, 123, 681, 124
257, 124, 681, 682
258, 124, 682, 125
259, 125, 682, 683
260, 125, 683, 126
261, 126, 683, 684
262, 126, 684, 8
263, 8, 684, 177
264, 164, 165, 675
265, 675, 165, 685
266, 675, 685, 676
267, 676, 685, 686
268, 676, 686, 677
269, 677, 686, 687
270, 677, 687, 678
271, 678, 687, 688
272, 678, 688, 679
273, 679, 688, 689
274, 679, 689, 680
275, 680, 689, 690
276, 680, 690, 681
277, 681, 690, 691
278, 681, 691, 682
279, 682, 691, 692
280, 682, 692, 683
281, 683, 692, 693
282, 683, 693, 684
283, 684, 693, 694
284, 684, 694, 177
285, 177, 694, 176
286, 165, 17, 685
287, 685, 17, 166
288, 685, 166, 686
289, 686, 166, 167
290, 686, 167, 687
291, 687, 167, 168
292, 687, 168, 688
293, 688, 168, 169
294, 688, 169, 689
295, 689, 169, 170
296, 689, 170, 690
297, 690, 170, 171
298, 690, 171, 691
299, 691, 171, 172
300, 691, 172, 692
301, 692, 172, 173
302, 692, 173, 693
303, 693, 173, 174
304, 693, 174, 694
305, 694, 174, 175
306, 694, 175, 176
307, 176, 175, 18
308, 8, 178, 127
309, 178, 695, 127
310, 178, 179, 695
311, 179, 696, 695
312, 179, 19, 696
313, 19, 180, 696
314, 127, 695, 3
315, 695, 130, 3
316, 695, 696, 130
317, 696, 131, 130
318, 696, 180, 131
319, 180, 9, 131
320, 14, 181, 132
321, 132, 181, 697
322, 132, 697, 15
323, 15, 697, 221
324, 181, 182, 697
325, 697, 182, 698
326, 697, 698, 221
327, 221, 698, 220
328, 182, 183, 698
329, 698, 183, 699
330, 698, 699, 220
331, 220, 699, 219
332, 183, 184, 699
333, 699, 184, 700
334, 699, 700, 219
335, 219, 700, 218
336, 184, 185, 700
337, 700, 185, 701
338, 700, 701, 218
339, 218, 701, 217
340, 185, 186, 701
341, 701, 186, 702
342, 701, 702, 217
343, 217, 702, 216
344, 186, 187, 702
345, 702, 187, 703
346, 702, 703, 216
347, 216, 703, 215
348, 187, 188, 703
349, 703, 188, 704
350, 703, 704, 215
351, 215, 704, 214
352, 188, 189, 704
353, 704, 189, 705
354, 704, 705, 214
355, 214, 705, 213
356, 189, 190, 705
357, 705, 190, 706
358, 705, 706, 213
359, 213, 706, 212
360, 190, 191, 706
361, 706, 191, 707
362, 706, 707, 212
363, 212, 707, 211
364, 191, 192, 707
365, 707, 192, 708
366, 707, 708, 211
367, 211, 708, 210
368, 192, 193, 708
369, 708, 193, 709
370, 708, 709, 210
371, 210, 709, 209
372, 193, 194, 709
373, 709, 194, 710
374, 709, 710, 209
375, 209, 710, 208
376, 194, 195, 710
377, 710, 195, 711
378, 710, 711, 208
379, 208, 711, 207
380, 195, 196, 711
381, 711, 196, 712
382, 711, 712, 207
383, 207, 712, 206
384, 196, 197, 712
385, 712, 197, 713
386, 712, 713, 206
387, 206, 713, 205
388, 197, 198, 713
389, 713, 198, 714
390, 713, 714, 205
391, 205, 714, 204
392, 198, 199, 714
393, 714, 199, 715
394, 714, 715, 204
395, 204, 715, 203
396, 199, 200, 715
397, 715, 200, 716
398, 715, 716, 203
399, 203, 716, 202
400, 200, 20, 716
401, 716, 20, 201
402, 716, 201, 202
403, 202, 201, 21
404, 6, 142, 163
405, 142, 717, 163
406, 142, 141, 717
407, 141, 718, 717
408, 141, 140, 718
409, 140, 719, 718
410, 140, 139, 719
411, 139, 720, 719
412, 139, 138, 720
413, 138, 721, 720
414, 138, 137, 721
415, 137, 722, 721
416, 137, 136, 722
417, 136, 723, 722
418, 136, 135, 723
419, 135, 724, 723
420, 135, 134, 724
421, 134, 725, 724
422, 134, 133, 725
423, 133, 726, 725
424, 133, 15, 726
425, 15, 222, 726
426, 163, 717, 16
427, 717, 232, 16
428, 717, 718, 232
429, 718, 231, 232
430, 718, 719, 231
431, 719, 230, 231
432, 719, 720, 230
433, 720, 229, 230
434, 720, 721, 229
435, 721, 228, 229
436, 721, 722, 228
437, 722, 227, 228
438, 722, 723, 227
439, 723, 226, 227
440, 723, 724, 226
441, 724, 225, 226
442, 724, 725, 225
443, 725, 224, 225
444, 725, 726, 224
445, 726, 223, 224
446, 726, 222, 223
447, 222, 22, 223
448, 16, 233, 153
449, 153, 233, 727
450, 153, 727, 154
451, 154, 727, 728
452, 154, 728, 155
453, 155, 728, 729
454, 155, 729, 156
455, 156, 729, 730
456, 156, 730, 157
457, 157, 730, 731
458, 157, 731, 158
459, 158, 731, 732
460, 158, 732, 159
461, 159, 732, 733
462, 159, 733, 160
463, 160, 733, 734
464, 160, 734, 161
465, 161, 734, 735
466, 161, 735, 162
467, 162, 735, 736
468, 162, 736, 7
469, 7, 736, 164
470, 233, 234, 727
471, 727, 234, 737
472, 727, 737, 728
473, 728, 737, 738
474, 728, 738, 729
475, 729, 738, 739
476, 729, 739, 730
477, 730, 739, 740
478, 730, 740, 731
479, 731, 740, 741
480, 731, 741, 732
481, 732, 741, 742
482, 732, 742, 733
483, 733, 742, 743
484, 733, 743, 734
485, 734, 743, 744
486, 734, 744, 735
487, 735, 744, 745
488, 735, 745, 736
489, 736, 745, 746
490, 736, 746, 164
491, 164, 746, 165
492, 234, 23, 737
493, 737, 23, 235
494, 737, 235, 738
495, 738, 235, 236
496, 738, 236, 739
497, 739, 236, 237
498, 739, 237, 740
499, 740, 237, 238
500, 740, 238, 741
501, 741, 238, 239
502, 741, 239, 742
503, 742, 239, 240
504, 742, 240, 743
505, 743, 240, 241
506, 743, 241, 744
507, 744, 241, 242
508, 744, 242, 745
509, 745, 242, 243
510, 745, 243, 746
511, 746, 243, 244
512, 746, 244, 165
513, 165, 244, 17
514, 24, 245, 256
515, 256, 245, 747
516, 256, 747, 17
517, 17, 747, 166
518, 245, 246, 747
519, 747, 246, 748
520, 747, 748, 166
521, 166, 748, 167
522, 246, 247, 748
523, 748, 247, 749
524, 748, 749, 167
525, 167, 749, 168
526, 247, 248, 749
527, 749, 248, 750
528, 749, 750, 168
529, 168, 750, 169
530, 248, 249, 750
531, 750, 249, 751
532, 750, 751, 169
533, 169, 751, 170
534, 249, 250, 751
535, 751, 250, 752
536, 751, 752, 170
537, 170, 752, 171
538, 250, 251, 752
539, 752, 251, 753
540, 752, 753, 171
541, 171, 753, 172
542, 251, 252, 753
543, 753, 252, 754
544, 753, 754, 172
545, 172, 754, 173
546, 252, 253, 754
547, 754, 253, 755
548, 754, 755, 173
549, 173, 755, 174
550, 253, 254, 755
551, 755, 254, 756
552, 755, 756, 174
553, 174, 756, 175
554, 254, 25, 756
555, 756, 25, 255
556, 756, 255, 175
557, 175, 255, 18
558, 177, 817, 8
559, 259, 775, 41
560, 45, 815, 762
561, 19, 802, 29
562, 775, 799, 41
563, 178, 817, 772
564, 786, 800, 760
565, 261, 815, 45
566, 29, 802, 765
567, 176, 804, 788
568, 179, 802, 19
569, 39, 790, 38
570, 27, 757, 26
571, 29, 765, 763
572, 791, 801, 781
573, 787, 797, 776
574, 37, 806, 36
575, 783, 803, 34
576, 46, 760, 261
577, 777, 787, 776
578, 760, 800, 780
579, 759, 783, 34
580, 257, 791, 759
581, 773, 778, 775
582, 46, 810, 760
583, 778, 785, 775
584, 777, 788, 787
585, 781, 797, 791
586, 773, 775, 259
587, 761, 801, 791
588, 758, 806, 37
589, 33, 784, 32
590, 808, 809, 801
591, 176, 792, 177
592, 35, 791, 257
593, 785, 799, 775
594, 772, 805, 802
595, 788, 792, 176
596, 759, 787, 783
597, 761, 791, 35
598, 258, 761, 35
599, 257, 759, 34
600, 762, 815, 796
601, 260, 773, 259
602, 26, 774, 46
603, 774, 811, 786
604, 780, 800, 789
605, 772, 802, 179
606, 791, 797, 759
607, 760, 780, 779
608, 759, 797, 787
609, 779, 807, 796
610, 807, 809, 778
611, 778, 809, 808
612, 27, 763, 757
613, 792, 794, 177
614, 770, 776, 771
615, 777, 792, 788
616, 760, 779, 261
617, 783, 804, 803
618, 773, 807, 778
619, 260, 812, 773
620, 768, 770, 769
621, 777, 793, 792
622, 779, 815, 261
623, 178, 772, 179
624, 801, 809, 789
625, 31, 798, 30
626, 807, 812, 796
627, 789, 809, 780
628, 776, 781, 771
629, 786, 810, 774
630, 770, 771, 769
631, 776, 797, 781
632, 781, 789, 771
633, 778, 808, 785
634, 782, 794, 793
635, 769, 786, 767
636, 768, 769, 767
637, 785, 806, 799
638, 770, 777, 776
639, 768, 793, 770
640, 765, 805, 766
641, 41, 790, 40
642, 793, 794, 792
643, 780, 807, 779
644, 763, 764, 757
645, 781, 801, 789
646, 766, 782, 768
647, 766, 768, 767
648, 786, 811, 767
649, 771, 800, 769
650, 789, 800, 771
651, 769, 800, 786
652, 774, 810, 46
653, 38, 790, 758
654, 782, 793, 768
655, 802, 805, 765
656, 788, 804, 783
657, 258, 813, 761
658, 760, 810, 786
659, 30, 798, 18
660, 766, 805, 782
661, 795, 812, 260
662, 780, 809, 807
663, 33, 803, 784
664, 787, 788, 783
665, 766, 767, 764
666, 806, 814, 36
667, 762, 796, 795
668, 770, 793, 777
669, 764, 811, 757
670, 765, 766, 764
671, 761, 808, 801
672, 796, 815, 779
673, 782, 816, 794
674, 40, 790, 39
675, 794, 817, 177
676, 785, 814, 806
677, 763, 765, 764
678, 790, 799, 758
679, 43, 762, 42
680, 757, 774, 26
681, 773, 812, 807
682, 803, 804, 784
683, 762, 795, 42
684, 808, 813, 785
685, 796, 812, 795
686, 767, 811, 764
687, 799, 806, 758
688, 757, 811, 774
689, 813, 814, 785
690, 761, 813, 808
691, 772, 816, 805
692, 44, 762, 43
693, 805, 816, 782
694, 258, 814, 813
695, 38, 758, 37
696, 28, 763, 27
697, 772, 817, 816
698, 816, 817, 794
699, 18, 798, 176
700, 29, 763, 28
701, 36, 814, 258
702, 42, 795, 260
703, 8, 817, 178
704, 32, 798, 31
705, 784, 798, 32
706, 34, 803, 33
707, 41, 799, 790
708, 45, 762, 44
709, 798, 804, 176
710, 784, 804, 798
711, 47, 262, 324
712, 324, 262, 818
713, 324, 818, 323
714, 323, 818, 819
715, 323, 819, 322
716, 322, 819, 820
717, 322, 820, 321
718, 321, 820, 821
719, 321, 821, 320
720, 320, 821, 822
721, 320, 822, 319
722, 319, 822, 823
723, 319, 823, 318
724, 318, 823, 824
725, 318, 824, 317
726, 317, 824, 825
727, 317, 825, 316
728, 316, 825, 826
729, 316, 826, 315
730, 315, 826, 827
731, 315, 827, 314
732, 314, 827, 828
733, 314, 828, 313
734, 313, 828, 829
735, 313, 829, 312
736, 312, 829, 830
737, 312, 830, 311
738, 311, 830, 831
739, 311, 831, 310
740, 310, 831, 832
741, 310, 832, 309
742, 309, 832, 833
743, 309, 833, 308
744, 308, 833, 834
745, 308, 834, 307
746, 307, 834, 835
747, 307, 835, 306
748, 306, 835, 836
749, 306, 836, 305
750, 305, 836, 837
751, 305, 837, 304
752, 304, 837, 838
753, 304, 838, 303
754, 303, 838, 839
755, 303, 839, 302
756, 302, 839, 840
757, 302, 840, 301
758, 301, 840, 841
759, 301, 841, 300
760, 300, 841, 842
761, 300, 842, 299
762, 299, 842, 843
763, 299, 843, 298
764, 298, 843, 844
765, 298, 844, 297
766, 297, 844, 845
767, 297, 845, 296
768, 296, 845, 846
769, 296, 846, 295
770, 295, 846, 847
771, 295, 847, 294
772, 294, 847, 848
773, 294, 848, 20
774, 20, 848, 201
775, 262, 48, 818
776, 818, 48, 263
777, 818, 263, 819
778, 819, 263, 264
779, 819, 264, 820
780, 820, 264, 265
781, 820, 265, 821
782, 821, 265, 266
783, 821, 266, 822
784, 822, 266, 267
785, 822, 267, 823
786, 823, 267, 268
787, 823, 268, 824
788, 824, 268, 269
789, 824, 269, 825
790, 825, 269, 270
791, 825, 270, 826
792, 826, 270, 271
793, 826, 271, 827
794, 827, 271, 272
795, 827, 272, 828
796, 828, 272, 273
797, 828, 273, 829
798, 829, 273, 274
799, 829, 274, 830
800, 830, 274, 275
801, 830, 275, 831
802, 831, 275, 276
803, 831, 276, 832
804, 832, 276, 277
805, 832, 277, 833
806, 833, 277, 278
807, 833, 278, 834
808, 834, 278, 279
809, 834, 279, 835
810, 835, 279, 280
811, 835, 280, 836
812, 836, 280, 281
813, 836, 281, 837
814, 837, 281, 282
815, 837, 282, 838
816, 838, 282, 283
817, 838, 283, 839
818, 839, 283, 284
819, 839, 284, 840
820, 840, 284, 285
821, 840, 285, 841
822, 841, 285, 286
823, 841, 286, 842
824, 842, 286, 287
825, 842, 287, 843
826, 843, 287, 288
827, 843, 288, 844
828, 844, 288, 289
829, 844, 289, 845
830, 845, 289, 290
831, 845, 290, 846
832, 846, 290, 291
833, 846, 291, 847
834, 847, 291, 292
835, 847, 292, 848
836, 848, 292, 293
837, 848, 293, 201
838, 201, 293, 21
839, 49, 325, 345
840, 345, 325, 849
841, 345, 849, 21
842, 21, 849, 202
843, 325, 326, 849
844, 849, 326, 850
845, 849, 850, 202
846, 202, 850, 203
847, 326, 327, 850
848, 850, 327, 851
849, 850, 851, 203
850, 203, 851, 204
851, 327, 328, 851
852, 851, 328, 852
853, 851, 852, 204
854, 204, 852, 205
855, 328, 329, 852
856, 852, 329, 853
857, 852, 853, 205
858, 205, 853, 206
859, 329, 330, 853
860, 853, 330, 854
861, 853, 854, 206
862, 206, 854, 207
863, 330, 331, 854
864, 854, 331, 855
865, 854, 855, 207
866, 207, 855, 208
867, 331, 332, 855
868, 855, 332, 856
869, 855, 856, 208
870, 208, 856, 209
871, 332, 333, 856
872, 856, 333, 857
873, 856, 857, 209
874, 209, 857, 210
875, 333, 334, 857
876, 857, 334, 858
877, 857, 858, 210
878, 210, 858, 211
879, 334, 335, 858
880, 858, 335, 859
881, 858, 859, 211
882, 211, 859, 212
883, 335, 336, 859
884, 859, 336, 860
885, 859, 860, 212
886, 212, 860, 213
887, 336, 337, 860
888, 860, 337, 861
889, 860, 861, 213
890, 213, 861, 214
891, 337, 338, 861
892, 861, 338, 862
893, 861, 862, 214
894, 214, 862, 215
895, 338, 339, 862
896, 862, 339, 863
897, 862, 863, 215
898, 215, 863, 216
899, 339, 340, 863
900, 863, 340, 864
901, 863, 864, 216
902, 216, 864, 217
903, 340, 341, 864
904, 864, 341, 865
905, 864, 865, 217
906, 217, 865, 218
907, 341, 342, 865
908, 865, 342, 866
909, 865, 866, 218
910, 218, 866, 219
911, 342, 343, 866
912, 866, 343, 867
913, 866, 867, 219
914, 219, 867, 220
915, 343, 344, 867
916, 867, 344, 868
917, 867, 868, 220
918, 220, 868, 221
919, 344, 22, 868
920, 868, 22, 222
921, 868, 222, 221
922, 221, 222, 15
923, 22, 346, 223
924, 223, 346, 869
925, 223, 869, 224
926, 224, 869, 870
927, 224, 870, 225
928, 225, 870, 871
929, 225, 871, 226
930, 226, 871, 872
931, 226, 872, 227
932, 227, 872, 873
933, 227, 873, 228
934, 228, 873, 874
935, 228, 874, 229
936, 229, 874, 875
937, 229, 875, 230
938, 230, 875, 876
939, 230, 876, 231
940, 231, 876, 877
941, 231, 877, 232
942, 232, 877, 878
943, 232, 878, 16
944, 16, 878, 233
945, 346, 347, 869
946, 869, 347, 879
947, 869, 879, 870
948, 870, 879, 880
949, 870, 880, 871
950, 871, 880, 881
951, 871, 881, 872
952, 872, 881, 882
953, 872, 882, 873
954, 873, 882, 883
955, 873, 883, 874
956, 874, 883, 884
957, 874, 884, 875
958, 875, 884, 885
959, 875, 885, 876
960, 876, 885, 886
961, 876, 886, 877
962, 877, 886, 887
963, 877, 887, 878
964, 878, 887, 888
965, 878, 888, 233
966, 233, 888, 234
967, 347, 50, 879
968, 879, 50, 348
969, 879, 348, 880
970, 880, 348, 349
971, 880, 349, 881
972, 881, 349, 350
973, 881, 350, 882
974, 882, 350, 351
975, 882, 351, 883
976, 883, 351, 352
977, 883, 352, 884
978, 884, 352, 353
979, 884, 353, 885
980, 885, 353, 354
981, 885, 354, 886
982, 886, 354, 355
983, 886, 355, 887
984, 887, 355, 356
985, 887, 356, 888
986, 888, 356, 357
987, 888, 357, 234
988, 234, 357, 23
989, 51, 358, 368
990, 368, 358, 889
991, 368, 889, 23
992, 23, 889, 235
993, 358, 359, 889
994, 889, 359, 890
995, 889, 890, 235
996, 235, 890, 236
997, 359, 360, 890
998, 890, 360, 891
999, 890, 891, 236
1000, 236, 891, 237
1001, 360, 361, 891
1002, 891, 361, 892
1003, 891, 892, 237
1004, 237, 892, 238
1005, 361, 362, 892
1006, 892, 362, 893
1007, 892, 893, 238
1008, 238, 893, 239
1009, 362, 363, 893
1010, 893, 363, 894
1011, 893, 894, 239
1012, 239, 894, 240
1013, 363, 364, 894
1014, 894, 364, 895
1015, 894, 895, 240
1016, 240, 895, 241
1017, 364, 365, 895
1018, 895, 365, 896
1019, 895, 896, 241
1020, 241, 896, 242
1021, 365, 366, 896
1022, 896, 366, 897
1023, 896, 897, 242
1024, 242, 897, 243
1025, 366, 367, 897
1026, 897, 367, 898
1027, 897, 898, 243
1028, 243, 898, 244
1029, 367, 24, 898
1030, 898, 24, 256
1031, 898, 256, 244
1032, 244, 256, 17
1033, 24, 369, 245
1034, 245, 369, 899
1035, 245, 899, 246
1036, 246, 899, 900
1037, 246, 900, 247
1038, 247, 900, 901
1039, 247, 901, 248
1040, 248, 901, 902
1041, 248, 902, 249
1042, 249, 902, 903
1043, 249, 903, 250
1044, 250, 903, 904
1045, 250, 904, 251
1046, 251, 904, 905
1047, 251, 905, 252
1048, 252, 905, 906
1049, 252, 906, 253
1050, 253, 906, 907
1051, 253, 907, 254
1052, 254, 907, 908
1053, 254, 908, 25
1054, 25, 908, 380
1055, 369, 52, 899
1056, 899, 52, 370
1057, 899, 370, 900
1058, 900, 370, 371
1059, 900, 371, 901
1060, 901, 371, 372
1061, 901, 372, 902
1062, 902, 372, 373
1063, 902, 373, 903
1064, 903, 373, 374
1065, 903, 374, 904
1066, 904, 374, 375
1067, 904, 375, 905
1068, 905, 375, 376
1069, 905, 376, 906
1070, 906, 376, 377
1071, 906, 377, 907
1072, 907, 377, 378
1073, 907, 378, 908
1074, 908, 378, 379
1075, 908, 379, 380
1076, 380, 379, 53
1077, 25, 54, 255
1078, 54, 381, 255
1079, 255, 381, 18
1080, 381, 30, 18
1081, 55, 383, 909
1082, 55, 909, 382
1083, 383, 48, 909
1084, 909, 48, 262
1085, 909, 262, 382
1086, 382, 262, 47
1087, 21, 293, 345
1088, 293, 910, 345
1089, 293, 292, 910
1090, 292, 911, 910
1091, 292, 291, 911
1092, 291, 912, 911
1093, 291, 290, 912
1094, 290, 913, 912
1095, 290, 289, 913
1096, 289, 914, 913
1097, 289, 288, 914
1098, 288, 915, 914
1099, 288, 287, 915
1100, 287, 916, 915
1101, 287, 286, 916
1102, 286, 917, 916
1103, 286, 285, 917
1104, 285, 918, 917
1105, 285, 284, 918
1106, 284, 919, 918
1107, 284, 283, 919
1108, 283, 920, 919
1109, 283, 282, 920
1110, 282, 921, 920
1111, 282, 281, 921
1112, 281, 922, 921
1113, 281, 280, 922
1114, 280, 923, 922
1115, 280, 279, 923
1116, 279, 924, 923
1117, 279, 278, 924
1118, 278, 925, 924
1119, 278, 277, 925
1120, 277, 926, 925
1121, 277, 276, 926
1122, 276, 927, 926
1123, 276, 275, 927
1124, 275, 928, 927
1125, 275, 274, 928
1126, 274, 929, 928
1127, 274, 273, 929
1128, 273, 930, 929
1129, 273, 272, 930
1130, 272, 931, 930
1131, 272, 271, 931
1132, 271, 932, 931
1133, 271, 270, 932
1134, 270, 933, 932
1135, 270, 269, 933
1136, 269, 934, 933
1137, 269, 268, 934
1138, 268, 935, 934
1139, 268, 267, 935
1140, 267, 936, 935
1141, 267, 266, 936
1142, 266, 937, 936
1143, 266, 265, 937
1144, 265, 938, 937
1145, 265, 264, 938
1146, 264, 939, 938
1147, 264, 263, 939
1148, 263, 940, 939
1149, 263, 48, 940
1150, 48, 384, 940
1151, 345, 910, 49
1152, 910, 415, 49
1153, 910, 911, 415
1154, 911, 414, 415
1155, 911, 912, 414
1156, 912, 413, 414
1157, 912, 913, 413
1158, 913, 412, 413
1159, 913, 914, 412
1160, 914, 411, 412
1161, 914, 915, 411
1162, 915, 410, 411
1163, 915, 916, 410
1164, 916, 409, 410
1165, 916, 917, 409
1166, 917, 408, 409
1167, 917, 918, 408
1168, 918, 407, 408
1169, 918, 919, 407
1170, 919, 406, 407
1171, 919, 920, 406
1172, 920, 405, 406
1173, 920, 921, 405
1174, 921, 404, 405
1175, 921, 922, 404
1176, 922, 403, 404
1177, 922, 923, 403
1178, 923, 402, 403
1179, 923, 924, 402
1180, 924, 401, 402
1181, 924, 925, 401
1182, 925, 400, 401
1183, 925, 926, 400
1184, 926, 399, 400
1185, 926, 927, 399
1186, 927, 398, 399
1187, 927, 928, 398
1188, 928, 397, 398
1189, 928, 929, 397
1190, 929, 396, 397
1191, 929, 930, 396
1192, 930, 395, 396
1193, 930, 931, 395
1194, 931, 394, 395
1195, 931, 932, 394
1196, 932, 393, 394
1197, 932, 933, 393
1198, 933, 392, 393
1199, 933, 934, 392
1200, 934, 391, 392
1201, 934, 935, 391
1202, 935, 390, 391
1203, 935, 936, 390
1204, 936, 389, 390
1205, 936, 937, 389
1206, 937, 388, 389
1207, 937, 938, 388
1208, 938, 387, 388
1209, 938, 939, 387
1210, 939, 386, 387
1211, 939, 940, 386
1212, 940, 385, 386
1213, 940, 384, 385
1214, 384, 56, 385
1215, 49, 416, 325
1216, 325, 416, 941
1217, 325, 941, 326
1218, 326, 941, 942
1219, 326, 942, 327
1220, 327, 942, 943
1221, 327, 943, 328
1222, 328, 943, 944
1223, 328, 944, 329
1224, 329, 944, 945
1225, 329, 945, 330
1226, 330, 945, 946
1227, 330, 946, 331
1228, 331, 946, 947
1229, 331, 947, 332
1230, 332, 947, 948
1231, 332, 948, 333
1232, 333, 948, 949
1233, 333, 949, 334
1234, 334, 949, 950
1235, 334, 950, 335
1236, 335, 950, 951
1237, 335, 951, 336
1238, 336, 951, 952
1239, 336, 952, 337
1240, 337, 952, 953
1241, 337, 953, 338
1242, 338, 953, 954
1243, 338, 954, 339
1244, 339, 954, 955
1245, 339, 955, 340
1246, 340, 955, 956
1247, 340, 956, 341
1248, 341, 956, 957
1249, 341, 957, 342
1250, 342, 957, 958
1251, 342, 958, 343
1252, 343, 958, 959
1253, 343, 959, 344
1254, 344, 959, 960
1255, 344, 960, 22
1256, 22, 960, 346
1257, 416, 417, 941
1258, 941, 417, 961
1259, 941, 961, 942
1260, 942, 961, 962
1261, 942, 962, 943
1262, 943, 962, 963
1263, 943, 963, 944
1264, 944, 963, 964
1265, 944, 964, 945
1266, 945, 964, 965
1267, 945, 965, 946
1268, 946, 965, 966
1269, 946, 966, 947
1270, 947, 966, 967
1271, 947, 967, 948
1272, 948, 967, 968
1273, 948, 968, 949
1274, 949, 968, 969
1275, 949, 969, 950
1276, 950, 969, 970
1277, 950, 970, 951
1278, 951, 970, 971
1279, 951, 971, 952
1280, 952, 971, 972
1281, 952, 972, 953
1282, 953, 972, 973
1283, 953, 973, 954
1284, 954, 973, 974
1285, 954, 974, 955
1286, 955, 974, 975
1287, 955, 975, 956
1288, 956, 975, 976
1289, 956, 976, 957
1290, 957, 976, 977
1291, 957, 977, 958
1292, 958, 977, 978
1293, 958, 978, 959
1294, 959, 978, 979
1295, 959, 979, 960
1296, 960, 979, 980
1297, 960, 980, 346
1298, 346, 980, 347
1299, 417, 57, 961
1300, 961, 57, 418
1301, 961, 418, 962
1302, 962, 418, 419
1303, 962, 419, 963
1304, 963, 419, 420
1305, 963, 420, 964
1306, 964, 420, 421
1307, 964, 421, 965
1308, 965, 421, 422
1309, 965, 422, 966
1310, 966, 422, 423
1311, 966, 423, 967
1312, 967, 423, 424
1313, 967, 424, 968
1314, 968, 424, 425
1315, 968, 425, 969
1316, 969, 425, 426
1317, 969, 426, 970
1318, 970, 426, 427
1319, 970, 427, 971
1320, 971, 427, 428
1321, 971, 428, 972
1322, 972, 428, 429
1323, 972, 429, 973
1324, 973, 429, 430
1325, 973, 430, 974
1326, 974, 430, 431
1327, 974, 431, 975
1328, 975, 431, 432
1329, 975, 432, 976
1330, 976, 432, 433
1331, 976, 433, 977
1332, 977, 433, 434
1333, 977, 434, 978
1334, 978, 434, 435
1335, 978, 435, 979
1336, 979, 435, 436
1337, 979, 436, 980
1338, 980, 436, 437
1339, 980, 437, 347
1340, 347, 437, 50
1341, 58, 438, 448
1342, 448, 438, 981
1343, 448, 981, 50
1344, 50, 981, 348
1345, 438, 439, 981
1346, 981, 439, 982
1347, 981, 982, 348
1348, 348, 982, 349
1349, 439, 440, 982
1350, 982, 440, 983
1351, 982, 983, 349
1352, 349, 983, 350
1353, 440, 441, 983
1354, 983, 441, 984
1355, 983, 984, 350
1356, 350, 984, 351
1357, 441, 442, 984
1358, 984, 442, 985
1359, 984, 985, 351
1360, 351, 985, 352
1361, 442, 443, 985
1362, 985, 443, 986
1363, 985, 986, 352
1364, 352, 986, 353
1365, 443, 444, 986
1366, 986, 444, 987
1367, 986, 987, 353
1368, 353, 987, 354
1369, 444, 445, 987
1370, 987, 445, 988
1371, 987, 988, 354
1372, 354, 988, 355
1373, 445, 446, 988
1374, 988, 446, 989
1375, 988, 989, 355
1376, 355, 989, 356
1377, 446, 447, 989
1378, 989, 447, 990
1379, 989, 990, 356
1380, 356, 990, 357
1381, 447, 51, 990
1382, 990, 51, 368
1383, 990, 368, 357
1384, 357, 368, 23
1385, 51, 449, 358
1386, 358, 449, 991
1387, 358, 991, 359
1388, 359, 991, 992
1389, 359, 992, 360
1390, 360, 992, 993
1391, 360, 993, 361
1392, 361, 993, 994
1393, 361, 994, 362
1394, 362, 994, 995
1395, 362, 995, 363
1396, 363, 995, 996
1397, 363, 996, 364
1398, 364, 996, 997
1399, 364, 997, 365
1400, 365, 997, 998
1401, 365, 998, 366
1402, 366, 998, 999
1403, 366, 999, 367
1404, 367, 999, 1000
1405, 367, 1000, 24
1406, 24, 1000, 369
1407, 449, 59, 991
1408, 991, 59, 450
1409, 991, 450, 992
1410, 992, 450, 451
1411, 992, 451, 993
1412, 993, 451, 452
1413, 993, 452, 994
1414, 994, 452, 453
1415, 994, 453, 995
1416, 995, 453, 454
1417, 995, 454, 996
1418, 996, 454, 455
1419, 996, 455, 997
1420, 997, 455, 456
1421, 997, 456, 998
1422, 998, 456, 457
1423, 998, 457, 999
1424, 999, 457, 458
1425, 999, 458, 1000
1426, 1000, 458, 459
1427, 1000, 459, 369
1428, 369, 459, 52
1429, 62, 1002, 61
1430, 1001, 1003, 63
1431, 380, 1003, 1001
1432, 62, 1003, 1002
1433, 25, 1001, 54
1434, 61, 1002, 60
1435, 1002, 1003, 380
1436, 63, 1003, 62
1437, 380, 1001, 25
1438, 54, 1001, 63
1439, 60, 1002, 53
1440, 53, 1002, 380
1441, 48, 383, 384
1442, 383, 1004, 384
1443, 383, 55, 1004
1444, 55, 460, 1004
1445, 384, 1004, 56
1446, 1004, 461, 56
1447, 1004, 460, 461
1448, 460, 64, 461
1449, 56, 462, 385
1450, 385, 462, 1005
1451, 385, 1005, 386
1452, 386, 1005, 1006
1453, 386, 1006, 387
1454, 387, 1006, 1007
1455, 387, 1007, 388
1456, 388, 1007, 1008
1457, 388, 1008, 389
1458, 389, 1008, 1009
1459, 389, 1009, 390
1460, 390, 1009, 1010
1461, 390, 1010, 391
1462, 391, 1010, 1011
1463, 391, 1011, 392
1464, 392, 1011, 1012
1465, 392, 1012, 393
1466, 393, 1012, 1013
1467, 393, 1013, 394
1468, 394, 1013, 1014
1469, 394, 1014, 395
1470, 395, 1014, 1015
1471, 395, 1015, 396
1472, 396, 1015, 1016
1473, 396, 1016, 397
1474, 397, 1016, 1017
1475, 397, 1017, 398
1476, 398, 1017, 1018
1477, 398, 1018, 399
1478, 399, 1018, 1019
1479, 399, 1019, 400
1480, 400, 1019, 1020
1481, 400, 1020, 401
1482, 401, 1020, 1021
1483, 401, 1021, 402
1484, 402, 1021, 1022
1485, 402, 1022, 403
1486, 403, 1022, 1023
1487, 403, 1023, 404
1488, 404, 1023, 1024
1489, 404, 1024, 405
1490, 405, 1024, 1025
1491, 405, 1025, 406
1492, 406, 1025, 1026
1493, 406, 1026, 407
1494, 407, 1026, 1027
1495, 407, 1027, 408
1496, 408, 1027, 1028
1497, 408, 1028, 409
1498, 409, 1028, 1029
1499, 409, 1029, 410
1500, 410, 1029, 1030
1501, 410, 1030, 411
1502, 411, 1030, 1031
1503, 411, 1031, 412
1504, 412, 1031, 1032
1505, 412, 1032, 413
1506, 413, 1032, 1033
1507, 413, 1033, 414
1508, 414, 1033, 1034
1509, 414, 1034, 415
1510, 415, 1034, 1035
1511, 415, 1035, 49
1512, 49, 1035, 416
1513, 462, 463, 1005
1514, 1005, 463, 1036
1515, 1005, 1036, 1006
1516, 1006, 1036, 1037
1517, 1006, 1037, 1007
1518, 1007, 1037, 1038
1519, 1007, 1038, 1008
1520, 1008, 1038, 1039
1521, 1008, 1039, 1009
1522, 1009, 1039, 1040
1523, 1009, 1040, 1010
1524, 1010, 1040, 1041
1525, 1010, 1041, 1011
1526, 1011, 1041, 1042
1527, 1011, 1042, 1012
1528, 1012, 1042, 1043
1529, 1012, 1043, 1013
1530, 1013, 1043, 1044
1531, 1013, 1044, 1014
1532, 1014, 1044, 1045
1533, 1014, 1045, 1015
1534, 1015, 1045, 1046
1535, 1015, 1046, 1016
1536, 1016, 1046, 1047
1537, 1016, 1047, 1017
1538, 1017, 1047, 1048
1539, 1017, 1048, 1018
1540, 1018, 1048, 1049
1541, 1018, 1049, 1019
1542, 1019, 1049, 1050
1543, 1019, 1050, 1020
1544, 1020, 1050, 1051
1545, 1020, 1051, 1021
1546, 1021, 1051, 1052
1547, 1021, 1052, 1022
1548, 1022, 1052, 1053
1549, 1022, 1053, 1023
1550, 1023, 1053, 1054
1551, 1023, 1054, 1024
1552, 1024, 1054, 1055
1553, 1024, 1055, 1025
1554, 1025, 1055, 1056
1555, 1025, 1056, 1026
1556, 1026, 1056, 1057
1557, 1026, 1057, 1027
1558, 1027, 1057, 1058
1559, 1027, 1058, 1028
1560, 1028, 1058, 1059
1561, 1028, 1059, 1029
1562, 1029, 1059, 1060
1563, 1029, 1060, 1030
1564, 1030, 1060, 1061
1565, 1030, 1061, 1031
1566, 1031, 1061, 1062
1567, 1031, 1062, 1032
1568, 1032, 1062, 1063
1569, 1032, 1063, 1033
1570, 1033, 1063, 1064
1571, 1033, 1064, 1034
1572, 1034, 1064, 1065
1573, 1034, 1065, 1035
1574, 1035, 1065, 1066
1575, 1035, 1066, 416
1576, 416, 1066, 417
1577, 463, 65, 1036
1578, 1036, 65, 464
1579, 1036, 464, 1037
1580, 1037, 464, 465
1581, 1037, 465, 1038
1582, 1038, 465, 466
1583, 1038, 466, 1039
1584, 1039, 466, 467
1585, 1039, 467, 1040
1586, 1040, 467, 468
1587, 1040, 468, 1041
1588, 1041, 468, 469
1589, 1041, 469, 1042
1590, 1042, 469, 470
1591, 1042, 470, 1043
1592, 1043, 470, 471
1593, 1043, 471, 1044
1594, 1044, 471, 472
1595, 1044, 472, 1045
1596, 1045, 472, 473
1597, 1045, 473, 1046
1598, 1046, 473, 474
1599, 1046, 474, 1047
1600, 1047, 474, 475
1601, 1047, 475, 1048
1602, 1048, 475, 476
1603, 1048, 476, 1049
1604, 1049, 476, 477
1605, 1049, 477, 1050
1606, 1050, 477, 478
1607, 1050, 478, 1051
1608, 1051, 478, 479
1609, 1051, 479, 1052
1610, 1052, 479, 480
1611, 1052, 480, 1053
1612, 1053, 480, 481
1613, 1053, 481, 1054
1614, 1054, 481, 482
1615, 1054, 482, 1055
1616, 1055, 482, 483
1617, 1055, 483, 1056
1618, 1056, 483, 484
1619, 1056, 484, 1057
1620, 1057, 484, 485
1621, 1057, 485, 1058
1622, 1058, 485, 486
1623, 1058, 486, 1059
1624, 1059, 486, 487
1625, 1059, 487, 1060
1626, 1060, 487, 488
1627, 1060, 488, 1061
1628, 1061, 488, 489
1629, 1061, 489, 1062
1630, 1062, 489, 490
1631, 1062, 490, 1063
1632, 1063, 490, 491
1633, 1063, 491, 1064
1634, 1064, 491, 492
1635, 1064, 492, 1065
1636, 1065, 492, 493
1637, 1065, 493, 1066
1638, 1066, 493, 494
1639, 1066, 494, 417
1640, 417, 494, 57
1641, 66, 495, 515
1642, 515, 495, 1067
1643, 515, 1067, 57
1644, 57, 1067, 418
1645, 495, 496, 1067
1646, 1067, 496, 1068
1647, 1067, 1068, 418
1648, 418, 1068, 419
1649, 496, 497, 1068
1650, 1068, 497, 1069
1651, 1068, 1069, 419
1652, 419, 1069, 420
1653, 497, 498, 1069
1654, 1069, 498, 1070
1655, 1069, 1070, 420
1656, 420, 1070, 421
1657, 498, 499, 1070
1658, 1070, 499, 1071
1659, 1070, 1071, 421
1660, 421, 1071, 422
1661, 499, 500, 1071
1662, 1071, 500, 1072
1663, 1071, 1072, 422
1664, 422, 1072, 423
1665, 500, 501, 1072
1666, 1072, 501, 1073
1667, 1072, 1073, 423
1668, 423, 1073, 424
1669, 501, 502, 1073
1670, 1073, 502, 1074
1671, 1073, 1074, 424
1672, 424, 1074, 425
1673, 502, 503, 1074
1674, 1074, 503, 1075
1675, 1074, 1075, 425
1676, 425, 1075, 426
1677, 503, 504, 1075
1678, 1075, 504, 1076
1679, 1075, 1076, 426
1680, 426, 1076, 427
1681, 504, 505, 1076
1682, 1076, 505, 1077
1683, 1076, 1077, 427
1684, 427, 1077, 428
1685, 505, 506, 1077
1686, 1077, 506, 1078
1687, 1077, 1078, 428
1688, 428, 1078, 429
1689, 506, 507, 1078
1690, 1078, 507, 1079
1691, 1078, 1079, 429
1692, 429, 1079, 430
1693, 507, 508, 1079
1694, 1079, 508, 1080
1695, 1079, 1080, 430
1696, 430, 1080, 431
1697, 508, 509, 1080
1698, 1080, 509, 1081
1699, 1080, 1081, 431
1700, 431, 1081, 432
1701, 509, 510, 1081
1702, 1081, 510, 1082
1703, 1081, 1082, 432
1704, 432, 1082, 433
1705, 510, 511, 1082
1706, 1082, 511, 1083
1707, 1082, 1083, 433
1708, 433, 1083, 434
1709, 511, 512, 1083
1710, 1083, 512, 1084
1711, 1083, 1084, 434
1712, 434, 1084, 435
1713, 512, 513, 1084
1714, 1084, 513, 1085
1715, 1084, 1085, 435
1716, 435, 1085, 436
1717, 513, 514, 1085
1718, 1085, 514, 1086
1719, 1085, 1086, 436
1720, 436, 1086, 437
1721, 514, 58, 1086
