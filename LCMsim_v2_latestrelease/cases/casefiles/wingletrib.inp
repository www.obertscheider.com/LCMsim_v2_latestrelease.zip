**
** Heading +++++++++++++++++++++++++++++++++++++++++++++++++
**
*Heading
Hash: aGyi9UKw, Date: 03/19/2025, Unit system: M_KG_S_C
**
** Nodes +++++++++++++++++++++++++++++++++++++++++++++++++++
**
*Node
1, 1.35526591E+001, 1.86680269E-001, -1.46012742E+000
2, 1.30574414E+001, 1.88005097E-001, -1.46136537E+000
3, 1.30577369E+001, 9.14816514E-002, -1.44434308E+000
4, 1.35526589E+001, 1.24825484E-001, -1.44922484E+000
5, 1.35530438E+001, 1.09598815E-001, -1.46057139E+000
6, 1.30575092E+001, 7.62923994E-002, -1.45463269E+000
7, 1.30466092E+001, 8.71294209E-002, -1.45654879E+000
8, 1.30466093E+001, 8.91888110E-002, -1.45517952E+000
9, 1.30465996E+001, 7.89624912E-002, -1.50205393E+000
10, 1.30571256E+001, 6.83089654E-002, -1.49999694E+000
11, 1.30575758E+001, 7.15086229E-002, -1.48044918E+000
12, 1.30465949E+001, 1.81750094E-001, -1.52017699E+000
13, 1.30466044E+001, 1.88177258E-001, -1.47398539E+000
14, 1.30568077E+001, 1.98986733E-001, -1.47574138E+000
15, 1.30564148E+001, 1.94049867E-001, -1.52212780E+000
16, 1.30566321E+001, 1.95999164E-001, -1.50215412E+000
17, 1.35528605E+001, 1.97413754E-001, -1.47388639E+000
18, 1.35529817E+001, 1.95309760E-001, -1.50097823E+000
19, 1.35531025E+001, 1.93799528E-001, -1.52097656E+000
20, 1.30466077E+001, 1.86630367E-001, -1.47235975E+000
21, 1.35528822E+001, 1.05443657E-001, -1.50587487E+000
22, 1.35426414E+001, 1.87359724E-001, -1.46026889E+000
23, 1.35326236E+001, 1.88039433E-001, -1.46040891E+000
24, 1.35226058E+001, 1.88719142E-001, -1.46054894E+000
25, 1.35125880E+001, 1.89398852E-001, -1.46068896E+000
26, 1.35025703E+001, 1.90078561E-001, -1.46082898E+000
27, 1.34925524E+001, 1.90758233E-001, -1.46096900E+000
28, 1.34826734E+001, 1.91258009E-001, -1.46107702E+000
29, 1.34727312E+001, 1.91728076E-001, -1.46117993E+000
30, 1.34632625E+001, 1.92175758E-001, -1.46127794E+000
31, 1.34533204E+001, 1.92645825E-001, -1.46138085E+000
32, 1.34433782E+001, 1.93115891E-001, -1.46148376E+000
33, 1.34334361E+001, 1.93585960E-001, -1.46158667E+000
34, 1.34233190E+001, 1.93955573E-001, -1.46167222E+000
35, 1.34135580E+001, 1.94235420E-001, -1.46174123E+000
36, 1.34037969E+001, 1.94515268E-001, -1.46181024E+000
37, 1.33935479E+001, 1.94809107E-001, -1.46188270E+000
38, 1.33837868E+001, 1.95088955E-001, -1.46195171E+000
39, 1.33740258E+001, 1.95368801E-001, -1.46202072E+000
40, 1.33641930E+001, 1.95596479E-001, -1.46208068E+000
41, 1.33541993E+001, 1.95707110E-001, -1.46212033E+000
42, 1.33442056E+001, 1.95817738E-001, -1.46215997E+000
43, 1.33342118E+001, 1.95928366E-001, -1.46219962E+000
44, 1.33242181E+001, 1.96038994E-001, -1.46223927E+000
45, 1.33147241E+001, 1.96144089E-001, -1.46227693E+000
46, 1.33047199E+001, 1.96244416E-001, -1.46231478E+000
47, 1.32945564E+001, 1.96188170E-001, -1.46232535E+000
48, 1.32849009E+001, 1.96134569E-001, -1.46233536E+000
49, 1.32747373E+001, 1.96078147E-001, -1.46234590E+000
50, 1.32650819E+001, 1.96024546E-001, -1.46235591E+000
51, 1.32549182E+001, 1.95968123E-001, -1.46236645E+000
52, 1.32452628E+001, 1.95914531E-001, -1.46237646E+000
53, 1.32355203E+001, 1.95728005E-001, -1.46236321E+000
54, 1.32252426E+001, 1.95497255E-001, -1.46234325E+000
55, 1.32154787E+001, 1.95278041E-001, -1.46232428E+000
56, 1.32057149E+001, 1.95058827E-001, -1.46230531E+000
57, 1.31954371E+001, 1.94828076E-001, -1.46228535E+000
58, 1.31856733E+001, 1.94608888E-001, -1.46226638E+000
59, 1.31758829E+001, 1.94284262E-001, -1.46222889E+000
60, 1.31660716E+001, 1.93876548E-001, -1.46217678E+000
61, 1.31562602E+001, 1.93468843E-001, -1.46212468E+000
62, 1.31459325E+001, 1.93039681E-001, -1.46206984E+000
63, 1.31361212E+001, 1.92631976E-001, -1.46201773E+000
64, 1.31263099E+001, 1.92224265E-001, -1.46196563E+000
65, 1.31165057E+001, 1.91770829E-001, -1.46190545E+000
66, 1.31067184E+001, 1.91207647E-001, -1.46182589E+000
67, 1.30969311E+001, 1.90644368E-001, -1.46174631E+000
68, 1.30866387E+001, 1.90031181E-001, -1.46165895E+000
69, 1.30769063E+001, 1.89355490E-001, -1.46155945E+000
70, 1.30671739E+001, 1.88679837E-001, -1.46145995E+000
71, 1.30574713E+001, 1.78255407E-001, -1.45964170E+000
72, 1.30575006E+001, 1.68699680E-001, -1.45795699E+000
73, 1.30575301E+001, 1.59047431E-001, -1.45625526E+000
74, 1.30575597E+001, 1.49395182E-001, -1.45455353E+000
75, 1.30575892E+001, 1.39742933E-001, -1.45285180E+000
76, 1.30576188E+001, 1.30090683E-001, -1.45115008E+000
77, 1.30576483E+001, 1.20438434E-001, -1.44944835E+000
78, 1.30576778E+001, 1.10786185E-001, -1.44774662E+000
79, 1.30577074E+001, 1.01133935E-001, -1.44604489E+000
80, 1.30677128E+001, 9.14928137E-002, -1.44432502E+000
81, 1.30776886E+001, 9.15040680E-002, -1.44430690E+000
82, 1.30876644E+001, 9.15152831E-002, -1.44428877E+000
83, 1.30977140E+001, 9.16167047E-002, -1.44428639E+000
84, 1.31077796E+001, 9.17378147E-002, -1.44428745E+000
85, 1.31173419E+001, 9.18528786E-002, -1.44428847E+000
86, 1.31274454E+001, 9.20387659E-002, -1.44430087E+000
87, 1.31375729E+001, 9.22657605E-002, -1.44432048E+000
88, 1.31471940E+001, 9.24814082E-002, -1.44433911E+000
89, 1.31573214E+001, 9.27084047E-002, -1.44435871E+000
90, 1.31669425E+001, 9.29240540E-002, -1.44437734E+000
91, 1.31770700E+001, 9.31510474E-002, -1.44439695E+000
92, 1.31866979E+001, 9.33857444E-002, -1.44441892E+000
93, 1.31968623E+001, 9.37171262E-002, -1.44445685E+000
94, 1.32065185E+001, 9.40319947E-002, -1.44449290E+000
95, 1.32166830E+001, 9.43634435E-002, -1.44453085E+000
96, 1.32268474E+001, 9.46948890E-002, -1.44456879E+000
97, 1.32365037E+001, 9.50097623E-002, -1.44460484E+000
98, 1.32466681E+001, 9.53410871E-002, -1.44464277E+000
99, 1.32563325E+001, 9.57838832E-002, -1.44470135E+000
100, 1.32659981E+001, 9.62458468E-002, -1.44476331E+000
101, 1.32761724E+001, 9.67321945E-002, -1.44482855E+000
102, 1.32858179E+001, 9.72734637E-002, -1.44490453E+000
103, 1.32959619E+001, 9.78790340E-002, -1.44499085E+000
104, 1.33055987E+001, 9.84543127E-002, -1.44507285E+000
105, 1.33157044E+001, 9.91297066E-002, -1.44517155E+000
106, 1.33257810E+001, 9.98580719E-002, -1.44527965E+000
107, 1.33353538E+001, 1.00550012E-001, -1.44538234E+000
108, 1.33453808E+001, 1.01335473E-001, -1.44550060E+000
109, 1.33553502E+001, 1.02187483E-001, -1.44563072E+000
110, 1.33653195E+001, 1.03039477E-001, -1.44576083E+000
111, 1.33752327E+001, 1.03938245E-001, -1.44589930E+000
112, 1.33850621E+001, 1.04906805E-001, -1.44605024E+000
113, 1.33948914E+001, 1.05875361E-001, -1.44620119E+000
114, 1.34046723E+001, 1.06875693E-001, -1.44635783E+000
115, 1.34143481E+001, 1.07944745E-001, -1.44652680E+000
116, 1.34245077E+001, 1.09067291E-001, -1.44670422E+000
117, 1.34341360E+001, 1.10161869E-001, -1.44687779E+000
118, 1.34440919E+001, 1.11393603E-001, -1.44707487E+000
119, 1.34540478E+001, 1.12625360E-001, -1.44727196E+000
120, 1.34635297E+001, 1.13798462E-001, -1.44745967E+000
121, 1.34734856E+001, 1.15030218E-001, -1.44765676E+000
122, 1.34834415E+001, 1.16261975E-001, -1.44785384E+000
123, 1.34933974E+001, 1.17493732E-001, -1.44805093E+000
124, 1.35028793E+001, 1.18666834E-001, -1.44823864E+000
125, 1.35128352E+001, 1.19898590E-001, -1.44843573E+000
126, 1.35227911E+001, 1.21130347E-001, -1.44863282E+000
127, 1.35327470E+001, 1.22362104E-001, -1.44882991E+000
128, 1.35427029E+001, 1.23593860E-001, -1.44902699E+000
129, 1.35526589E+001, 1.35773845E-001, -1.45115423E+000
130, 1.35526589E+001, 1.49319958E-001, -1.45354238E+000
131, 1.35526589E+001, 1.62927926E-001, -1.45594143E+000
132, 1.35526589E+001, 1.76102912E-001, -1.45826415E+000
133, 1.35529368E+001, 1.14535842E-001, -1.45176618E+000
134, 1.35426508E+001, 1.08241358E-001, -1.46031679E+000
135, 1.35324615E+001, 1.06926520E-001, -1.46006905E+000
136, 1.35231830E+001, 1.05738402E-001, -1.45984567E+000
137, 1.35127053E+001, 1.04407614E-001, -1.45959609E+000
138, 1.35031555E+001, 1.03205161E-001, -1.45937122E+000
139, 1.34931791E+001, 1.01960203E-001, -1.45913917E+000
140, 1.34834774E+001, 1.00761095E-001, -1.45891651E+000
141, 1.34734433E+001, 9.95337035E-002, -1.45868961E+000
142, 1.34637464E+001, 9.83608248E-002, -1.45847393E+000
143, 1.34538268E+001, 9.71757061E-002, -1.45825736E+000
144, 1.34443168E+001, 9.60548847E-002, -1.45805409E+000
145, 1.34341923E+001, 9.48801610E-002, -1.45784305E+000
146, 1.34241190E+001, 9.37333689E-002, -1.45763950E+000
147, 1.34145628E+001, 9.26708283E-002, -1.45745328E+000
148, 1.34045079E+001, 9.15860028E-002, -1.45726543E+000
149, 1.33947771E+001, 9.05744486E-002, -1.45709206E+000
150, 1.33847785E+001, 8.95788911E-002, -1.45692259E+000
151, 1.33747798E+001, 8.86296978E-002, -1.45676132E+000
152, 1.33650589E+001, 8.77502526E-002, -1.45661138E+000
153, 1.33551511E+001, 8.68953896E-002, -1.45646498E+000
154, 1.33450986E+001, 8.60690190E-002, -1.45632308E+000
155, 1.33354075E+001, 8.53104546E-002, -1.45619274E+000
156, 1.33256612E+001, 8.45849611E-002, -1.45606826E+000
157, 1.33154325E+001, 8.38641723E-002, -1.45594506E+000
158, 1.33056898E+001, 8.32171785E-002, -1.45583523E+000
159, 1.32955211E+001, 8.25837999E-002, -1.45572832E+000
160, 1.32858410E+001, 8.20205973E-002, -1.45563316E+000
161, 1.32757156E+001, 8.14726996E-002, -1.45553968E+000
162, 1.32660538E+001, 8.09887580E-002, -1.45545543E+000
163, 1.32559235E+001, 8.05214364E-002, -1.45537139E+000
164, 1.32462341E+001, 8.01120993E-002, -1.45529423E+000
165, 1.32360554E+001, 7.97194872E-002, -1.45521610E+000
166, 1.32263157E+001, 7.93750204E-002, -1.45514461E+000
167, 1.32160920E+001, 7.90409881E-002, -1.45507369E+000
168, 1.32063182E+001, 7.87431470E-002, -1.45501047E+000
169, 1.31965342E+001, 7.84614087E-002, -1.45495226E+000
170, 1.31862781E+001, 7.81783732E-002, -1.45489742E+000
171, 1.31764859E+001, 7.79164089E-002, -1.45485143E+000
172, 1.31666928E+001, 7.76637423E-002, -1.45481141E+000
173, 1.31564326E+001, 7.74125610E-002, -1.45477528E+000
174, 1.31466377E+001, 7.71895610E-002, -1.45474570E+000
175, 1.31368419E+001, 7.69863574E-002, -1.45472032E+000
176, 1.31270452E+001, 7.68066604E-002, -1.45469853E+000
177, 1.31167811E+001, 7.66469958E-002, -1.45467899E+000
178, 1.31069825E+001, 7.65234990E-002, -1.45466320E+000
179, 1.30971830E+001, 7.64273835E-002, -1.45465035E+000
180, 1.30869159E+001, 7.63545567E-002, -1.45464030E+000
181, 1.30771146E+001, 7.63105216E-002, -1.45463415E+000
182, 1.30673123E+001, 7.62901983E-002, -1.45463154E+000
183, 1.30569823E+001, 8.17546421E-002, -1.44636258E+000
184, 1.30497576E+001, 7.96090288E-002, -1.45481753E+000
185, 1.30498441E+001, 9.05842412E-002, -1.44747200E+000
186, 1.30466076E+001, 8.54152792E-002, -1.46563283E+000
187, 1.30466054E+001, 8.37353807E-002, -1.47472325E+000
188, 1.30466034E+001, 8.20927217E-002, -1.48382048E+000
189, 1.30466013E+001, 8.05032054E-002, -1.49292714E+000
190, 1.30497435E+001, 7.15909958E-002, -1.50065075E+000
191, 1.30573507E+001, 6.99110325E-002, -1.49021272E+000
192, 1.30575315E+001, 7.46852006E-002, -1.46330705E+000
193, 1.30575537E+001, 7.30971359E-002, -1.47187813E+000
194, 1.30465991E+001, 9.30460498E-002, -1.50452740E+000
195, 1.30465983E+001, 1.08360884E-001, -1.50723068E+000
196, 1.30465975E+001, 1.23778502E-001, -1.50995210E+000
197, 1.30465966E+001, 1.39093335E-001, -1.51265537E+000
198, 1.30465958E+001, 1.54510953E-001, -1.51537679E+000
199, 1.30465949E+001, 1.69825787E-001, -1.51808007E+000
200, 1.30465961E+001, 1.83041969E-001, -1.51089248E+000
201, 1.30465979E+001, 1.84327400E-001, -1.50165416E+000
202, 1.30465996E+001, 1.85612830E-001, -1.49241584E+000
203, 1.30466014E+001, 1.86898261E-001, -1.48317752E+000
204, 1.30466037E+001, 1.77668292E-001, -1.47217199E+000
205, 1.30466043E+001, 1.67765614E-001, -1.47046321E+000
206, 1.30466048E+001, 1.57862935E-001, -1.46875442E+000
207, 1.30466053E+001, 1.48061305E-001, -1.46706307E+000
208, 1.30466059E+001, 1.37754435E-001, -1.46528454E+000
209, 1.30466064E+001, 1.27952805E-001, -1.46359319E+000
210, 1.30466070E+001, 1.18050126E-001, -1.46188440E+000
211, 1.30466075E+001, 1.08147448E-001, -1.46017562E+000
212, 1.30466081E+001, 9.69311491E-002, -1.45824016E+000
213, 1.30495853E+001, 1.95588288E-001, -1.47479507E+000
214, 1.30492835E+001, 1.89649863E-001, -1.52131263E+000
215, 1.30565266E+001, 1.94994815E-001, -1.51207101E+000
216, 1.30566925E+001, 1.96962009E-001, -1.49324812E+000
217, 1.30567500E+001, 1.97967561E-001, -1.48448059E+000
218, 1.30667379E+001, 1.99712368E-001, -1.47584464E+000
219, 1.30766703E+001, 2.00396762E-001, -1.47594024E+000
220, 1.30866047E+001, 2.01042267E-001, -1.47602842E+000
221, 1.30965409E+001, 2.01650050E-001, -1.47610931E+000
222, 1.31064786E+001, 2.02221279E-001, -1.47618301E+000
223, 1.31164177E+001, 2.02757119E-001, -1.47624964E+000
224, 1.31263579E+001, 2.03258647E-001, -1.47630905E+000
225, 1.31362994E+001, 2.03726522E-001, -1.47636080E+000
226, 1.31462418E+001, 2.04161356E-001, -1.47640502E+000
227, 1.31561851E+001, 2.04563763E-001, -1.47644190E+000
228, 1.31661290E+001, 2.04934359E-001, -1.47647159E+000
229, 1.31760734E+001, 2.05273759E-001, -1.47649428E+000
230, 1.31860181E+001, 2.05582588E-001, -1.47651021E+000
231, 1.31959627E+001, 2.05861505E-001, -1.47652010E+000
232, 1.32059070E+001, 2.06111102E-001, -1.47652450E+000
233, 1.32158509E+001, 2.06331965E-001, -1.47652388E+000
234, 1.32257940E+001, 2.06524676E-001, -1.47651871E+000
235, 1.32357361E+001, 2.06689820E-001, -1.47650946E+000
236, 1.32456771E+001, 2.06827988E-001, -1.47649660E+000
237, 1.32556169E+001, 2.06939813E-001, -1.47647996E+000
238, 1.32655555E+001, 2.07025467E-001, -1.47645938E+000
239, 1.32754928E+001, 2.07084998E-001, -1.47643485E+000
240, 1.32854286E+001, 2.07118451E-001, -1.47640634E+000
241, 1.32953630E+001, 2.07125873E-001, -1.47637384E+000
242, 1.33052958E+001, 2.07107309E-001, -1.47633732E+000
243, 1.33152270E+001, 2.07062641E-001, -1.47629645E+000
244, 1.33251566E+001, 2.06991531E-001, -1.47625089E+000
245, 1.33350845E+001, 2.06893695E-001, -1.47620068E+000
246, 1.33450106E+001, 2.06768848E-001, -1.47614584E+000
247, 1.33549349E+001, 2.06616709E-001, -1.47608640E+000
248, 1.33648571E+001, 2.06436993E-001, -1.47602238E+000
249, 1.33747773E+001, 2.06229430E-001, -1.47595362E+000
250, 1.33846954E+001, 2.05993810E-001, -1.47587976E+000
251, 1.33946114E+001, 2.05729929E-001, -1.47580093E+000
252, 1.34045249E+001, 2.05437585E-001, -1.47571727E+000
253, 1.34144361E+001, 2.05116572E-001, -1.47562893E+000
254, 1.34243446E+001, 2.04766687E-001, -1.47553605E+000
255, 1.34342503E+001, 2.04387749E-001, -1.47543865E+000
256, 1.34441534E+001, 2.03979603E-001, -1.47533613E+000
257, 1.34540537E+001, 2.03541836E-001, -1.47522853E+000
258, 1.34639509E+001, 2.03074001E-001, -1.47511606E+000
259, 1.34738448E+001, 2.02575652E-001, -1.47499890E+000
260, 1.34837354E+001, 2.02046342E-001, -1.47487725E+000
261, 1.34936224E+001, 2.01485621E-001, -1.47475123E+000
262, 1.35035058E+001, 2.00892860E-001, -1.47461979E+000
263, 1.35133854E+001, 2.00267202E-001, -1.47448313E+000
264, 1.35232609E+001, 1.99607778E-001, -1.47434212E+000
265, 1.35331320E+001, 1.98913783E-001, -1.47419636E+000
266, 1.35429987E+001, 1.98184402E-001, -1.47404504E+000
267, 1.35529319E+001, 1.96438532E-001, -1.48711116E+000
268, 1.35530168E+001, 1.94557684E-001, -1.51041455E+000
269, 1.35407104E+001, 1.94750359E-001, -1.52126536E+000
270, 1.35253370E+001, 1.95841282E-001, -1.52147263E+000
271, 1.35104547E+001, 1.96811296E-001, -1.52165960E+000
272, 1.34950714E+001, 1.97729176E-001, -1.52183939E+000
273, 1.34796835E+001, 1.98565170E-001, -1.52200619E+000
274, 1.34647876E+001, 1.99298764E-001, -1.52215562E+000
275, 1.34493909E+001, 1.99980994E-001, -1.52229800E+000
276, 1.34344867E+001, 2.00569889E-001, -1.52242446E+000
277, 1.34190822E+001, 2.01106706E-001, -1.52254375E+000
278, 1.34036763E+001, 2.01571842E-001, -1.52265166E+000
279, 1.33887665E+001, 2.01954763E-001, -1.52274540E+000
280, 1.33733592E+001, 2.02282088E-001, -1.52283141E+000
281, 1.33584485E+001, 2.02533718E-001, -1.52290430E+000
282, 1.33430402E+001, 2.02727183E-001, -1.52296904E+000
283, 1.33276314E+001, 2.02853604E-001, -1.52302313E+000
284, 1.33127191E+001, 2.02912686E-001, -1.52306542E+000
285, 1.32973091E+001, 2.02908956E-001, -1.52309884E+000
286, 1.32823958E+001, 2.02842981E-001, -1.52312126E+000
287, 1.32669847E+001, 2.02710353E-001, -1.52313420E+000
288, 1.32515732E+001, 2.02512182E-001, -1.52313671E+000
289, 1.32366585E+001, 2.02257957E-001, -1.52312923E+000
290, 1.32212487E+001, 2.01930398E-001, -1.52311119E+000
291, 1.32063388E+001, 2.01550018E-001, -1.52308365E+000
292, 1.31909349E+001, 2.01090796E-001, -1.52304467E+000
293, 1.31755342E+001, 2.00563634E-001, -1.52299489E+000
294, 1.31606332E+001, 1.99987950E-001, -1.52293630E+000
295, 1.31452387E+001, 1.99324663E-001, -1.52286488E+000
296, 1.31303439E+001, 1.98615966E-001, -1.52278514E+000
297, 1.31149557E+001, 1.97813964E-001, -1.52269166E+000
298, 1.30995709E+001, 1.96938743E-001, -1.52258654E+000
299, 1.30846858E+001, 1.96017298E-001, -1.52247297E+000
300, 1.30693082E+001, 1.94983117E-001, -1.52234258E+000
301, 1.35528371E+001, 1.94681474E-001, -1.46493123E+000
302, 1.30564905E+001, 1.96377817E-001, -1.46633232E+000
303, 1.30497876E+001, 1.87936286E-001, -1.46473377E+000
304, 1.30466070E+001, 1.76788764E-001, -1.47062458E+000
305, 1.30466073E+001, 1.67044609E-001, -1.46890656E+000
306, 1.30466076E+001, 1.57397895E-001, -1.46720571E+000
307, 1.30466079E+001, 1.47653741E-001, -1.46548768E+000
308, 1.30466082E+001, 1.37909586E-001, -1.46376966E+000
309, 1.30466085E+001, 1.28165431E-001, -1.46205163E+000
310, 1.30466088E+001, 1.18421276E-001, -1.46033360E+000
311, 1.30466092E+001, 1.08579679E-001, -1.45859839E+000
312, 1.30466095E+001, 9.88355244E-002, -1.45688037E+000
313, 1.30710625E+001, 6.83727703E-002, -1.50005499E+000
314, 1.30859938E+001, 6.85064944E-002, -1.50005641E+000
315, 1.31014216E+001, 6.87044911E-002, -1.50006825E+000
316, 1.31163508E+001, 6.89545073E-002, -1.50008984E+000
317, 1.31317766E+001, 6.92735034E-002, -1.50012267E+000
318, 1.31467039E+001, 6.96398514E-002, -1.50016444E+000
319, 1.31616299E+001, 7.00614423E-002, -1.50021580E+000
320, 1.31770517E+001, 7.05535948E-002, -1.50027867E+000
321, 1.31919738E+001, 7.10829601E-002, -1.50034873E+000
322, 1.32068929E+001, 7.16627620E-002, -1.50042754E+000
323, 1.32223061E+001, 7.23130946E-002, -1.50051786E+000
324, 1.32372191E+001, 7.29920567E-002, -1.50061388E+000
325, 1.32526258E+001, 7.37507115E-002, -1.50072300E+000
326, 1.32675311E+001, 7.45554025E-002, -1.50084083E+000
327, 1.32824313E+001, 7.54434366E-002, -1.50097314E+000
328, 1.32978224E+001, 7.64559800E-002, -1.50112632E+000
329, 1.33127115E+001, 7.75262097E-002, -1.50129024E+000
330, 1.33280914E+001, 7.87209997E-002, -1.50147505E+000
331, 1.33429702E+001, 7.99617771E-002, -1.50166857E+000
332, 1.33578439E+001, 8.12877552E-002, -1.50187687E+000
333, 1.33732055E+001, 8.27521362E-002, -1.50210847E+000
334, 1.33880603E+001, 8.42625334E-002, -1.50234879E+000
335, 1.34033979E+001, 8.59194678E-002, -1.50261382E+000
336, 1.34182290E+001, 8.76150167E-002, -1.50288629E+000
337, 1.34330489E+001, 8.93973849E-002, -1.50317384E+000
338, 1.34483526E+001, 9.13191661E-002, -1.50348486E+000
339, 1.34631550E+001, 9.32385315E-002, -1.50379620E+000
340, 1.34784453E+001, 9.52648429E-002, -1.50412537E+000
341, 1.34932393E+001, 9.72496066E-002, -1.50444806E+000
342, 1.35080316E+001, 9.92478282E-002, -1.50477309E+000
343, 1.35233145E+001, 1.01331717E-001, -1.50511226E+000
344, 1.35381013E+001, 1.03372972E-001, -1.50544476E+000
345, 1.35530082E+001, 1.06706727E-001, -1.49000190E+000
346, 1.35530676E+001, 1.08191025E-001, -1.47414768E+000
347, 1.35386095E+001, 1.78369408E-001, -1.45869205E+000
348, 1.35170991E+001, 1.79958183E-001, -1.45901550E+000
349, 1.34973022E+001, 1.81641161E-001, -1.45935210E+000
350, 1.34774987E+001, 1.81988842E-001, -1.45945331E+000
351, 1.34580200E+001, 1.82108777E-001, -1.45951372E+000
352, 1.34382180E+001, 1.83575767E-001, -1.45981226E+000
353, 1.34182250E+001, 1.84580439E-001, -1.46002968E+000
354, 1.33986103E+001, 1.85041809E-001, -1.46015055E+000
355, 1.33789332E+001, 1.85693838E-001, -1.46030516E+000
356, 1.33589070E+001, 1.85693557E-001, -1.46034547E+000
357, 1.33388635E+001, 1.86034735E-001, -1.46044602E+000
358, 1.33191148E+001, 1.86665830E-001, -1.46059709E+000
359, 1.32994771E+001, 1.87368654E-001, -1.46076057E+000
360, 1.32801402E+001, 1.86690295E-001, -1.46067995E+000
361, 1.32602440E+001, 1.87159528E-001, -1.46080278E+000
362, 1.32404936E+001, 1.86713615E-001, -1.46076397E+000
363, 1.32207516E+001, 1.85976672E-001, -1.46067384E+000
364, 1.32010565E+001, 1.85810194E-001, -1.46068419E+000
365, 1.31812640E+001, 1.84976178E-001, -1.46057705E+000
366, 1.31614565E+001, 1.83978520E-001, -1.46044109E+000
367, 1.31417083E+001, 1.82832741E-001, -1.46027889E+000
368, 1.31215835E+001, 1.81164927E-001, -1.46002542E+000
369, 1.31021714E+001, 1.81188847E-001, -1.46006876E+000
370, 1.30813595E+001, 1.80907207E-001, -1.46006106E+000
371, 1.30695223E+001, 1.77526161E-001, -1.45948885E+000
372, 1.30677029E+001, 1.64971037E-001, -1.45727908E+000
373, 1.30676067E+001, 1.44561923E-001, -1.45368119E+000
374, 1.30670083E+001, 1.25286454E-001, -1.45028418E+000
375, 1.30657982E+001, 1.06641071E-001, -1.44699948E+000
376, 1.30670506E+001, 9.80846838E-002, -1.44548848E+000
377, 1.30834439E+001, 9.91023482E-002, -1.44563485E+000
378, 1.31021791E+001, 1.02312608E-001, -1.44616305E+000
379, 1.31220972E+001, 1.02721514E-001, -1.44619500E+000
380, 1.31420958E+001, 1.02768419E-001, -1.44616296E+000
381, 1.31618864E+001, 1.03349634E-001, -1.44622554E+000
382, 1.31817190E+001, 1.03892872E-001, -1.44628133E+000
383, 1.32014916E+001, 1.04829569E-001, -1.44640662E+000
384, 1.32214627E+001, 1.04850938E-001, -1.44637013E+000
385, 1.32414138E+001, 1.05356128E-001, -1.44641899E+000
386, 1.32606422E+001, 1.05975168E-001, -1.44648937E+000
387, 1.32800912E+001, 1.07892914E-001, -1.44678826E+000
388, 1.32999709E+001, 1.09756097E-001, -1.44707667E+000
389, 1.33197263E+001, 1.11257540E-001, -1.44730155E+000
390, 1.33394762E+001, 1.11782440E-001, -1.44735428E+000
391, 1.33593087E+001, 1.12100651E-001, -1.44737041E+000
392, 1.33791538E+001, 1.14461322E-001, -1.44774659E+000
393, 1.33987409E+001, 1.16802089E-001, -1.44811978E+000
394, 1.34183720E+001, 1.17671639E-001, -1.44823352E+000
395, 1.34381637E+001, 1.20624637E-001, -1.44871423E+000
396, 1.34577980E+001, 1.24027899E-001, -1.44927464E+000
397, 1.34772937E+001, 1.24306142E-001, -1.44928440E+000
398, 1.34970676E+001, 1.27362050E-001, -1.44978330E+000
399, 1.35167755E+001, 1.29667771E-001, -1.45015007E+000
400, 1.35367267E+001, 1.30723554E-001, -1.45029599E+000
401, 1.35452785E+001, 1.31330937E-001, -1.45038583E+000
402, 1.35401329E+001, 1.56525456E-001, -1.45483794E+000
403, 1.35274175E+001, 1.79060944E-001, -1.45883652E+000
404, 1.35070155E+001, 1.80701620E-001, -1.45916689E+000
405, 1.34870143E+001, 1.82047875E-001, -1.45944454E+000
406, 1.34678378E+001, 1.82115359E-001, -1.45949509E+000
407, 1.34479087E+001, 1.82813321E-001, -1.45965831E+000
408, 1.34284550E+001, 1.84172302E-001, -1.45993710E+000
409, 1.34086239E+001, 1.84778326E-001, -1.46008391E+000
410, 1.33886036E+001, 1.85434032E-001, -1.46023986E+000
411, 1.33687254E+001, 1.85755036E-001, -1.46033652E+000
412, 1.33489660E+001, 1.85685456E-001, -1.46036408E+000
413, 1.33289256E+001, 1.86395695E-001, -1.46052969E+000
414, 1.33096525E+001, 1.87399916E-001, -1.46074557E+000
415, 1.32899731E+001, 1.86561346E-001, -1.46063740E+000
416, 1.32701204E+001, 1.87024423E-001, -1.46075905E+000
417, 1.32502372E+001, 1.87055667E-001, -1.46080464E+000
418, 1.32310705E+001, 1.86387104E-001, -1.46072540E+000
419, 1.32107630E+001, 1.85833407E-001, -1.46066872E+000
420, 1.31908774E+001, 1.85432200E-001, -1.46063807E+000
421, 1.31716111E+001, 1.84491358E-001, -1.46051103E+000
422, 1.31515982E+001, 1.83500890E-001, -1.46037675E+000
423, 1.31318122E+001, 1.81783250E-001, -1.46011381E+000
424, 1.31118144E+001, 1.81147615E-001, -1.46004206E+000
425, 1.30918358E+001, 1.81923425E-001, -1.46021910E+000
426, 1.30674923E+001, 1.34806213E-001, -1.45196151E+000
427, 1.30675051E+001, 1.54540718E-001, -1.45544063E+000
428, 1.30660176E+001, 1.16002123E-001, -1.44864937E+000
429, 1.30752363E+001, 1.02446170E-001, -1.44624091E+000
430, 1.30923353E+001, 1.01187818E-001, -1.44598460E+000
431, 1.31121198E+001, 1.02686122E-001, -1.44620887E+000
432, 1.31320681E+001, 1.02584994E-001, -1.44615083E+000
433, 1.31520641E+001, 1.02824552E-001, -1.44615276E+000
434, 1.31717938E+001, 1.03597068E-001, -1.44624919E+000
435, 1.31915774E+001, 1.04498473E-001, -1.44636823E+000
436, 1.32114959E+001, 1.04792708E-001, -1.44637996E+000
437, 1.32313548E+001, 1.05093951E-001, -1.44639304E+000
438, 1.32511457E+001, 1.05694929E-001, -1.44645910E+000
439, 1.32706865E+001, 1.06648131E-001, -1.44658776E+000
440, 1.32899828E+001, 1.08877595E-001, -1.44694192E+000
441, 1.33096837E+001, 1.10590556E-001, -1.44720420E+000
442, 1.33295799E+001, 1.11658047E-001, -1.44735230E+000
443, 1.33495570E+001, 1.11621838E-001, -1.44730565E+000
444, 1.33691189E+001, 1.13144304E-001, -1.44753463E+000
445, 1.33887353E+001, 1.15738733E-001, -1.44795248E+000
446, 1.34088861E+001, 1.17261252E-001, -1.44818028E+000
447, 1.34282103E+001, 1.18958542E-001, -1.44844056E+000
448, 1.34479695E+001, 1.22666944E-001, -1.44905452E+000
449, 1.34678725E+001, 1.24126815E-001, -1.44927178E+000
450, 1.34870950E+001, 1.25513947E-001, -1.44947758E+000
451, 1.35068737E+001, 1.28709217E-001, -1.45000104E+000
452, 1.35272139E+001, 1.29685311E-001, -1.45013212E+000
453, 1.35418587E+001, 1.42088694E-001, -1.45228929E+000
454, 1.35435426E+001, 1.68468966E-001, -1.45693668E+000
455, 1.35215129E+001, 1.69186845E-001, -1.45710764E+000
456, 1.31868136E+001, 1.74181999E-001, -1.45866287E+000
457, 1.34732305E+001, 1.70981683E-001, -1.45752138E+000
458, 1.35007027E+001, 1.71081955E-001, -1.45748369E+000
459, 1.34529337E+001, 1.70745633E-001, -1.45752067E+000
460, 1.34331935E+001, 1.72440928E-001, -1.45785934E+000
461, 1.34132316E+001, 1.73498173E-001, -1.45808596E+000
462, 1.33935288E+001, 1.74122868E-001, -1.45823581E+000
463, 1.33739226E+001, 1.74899268E-001, -1.45841220E+000
464, 1.33541066E+001, 1.73563450E-001, -1.45821664E+000
465, 1.33337086E+001, 1.73831924E-001, -1.45830508E+000
466, 1.33135224E+001, 1.75389648E-001, -1.45862039E+000
467, 1.32953055E+001, 1.74925246E-001, -1.45857524E+000
468, 1.32753896E+001, 1.75228966E-001, -1.45866892E+000
469, 1.32552012E+001, 1.76602958E-001, -1.45895185E+000
470, 1.32064620E+001, 1.75321802E-001, -1.45882422E+000
471, 1.31672295E+001, 1.73051095E-001, -1.45850297E+000
472, 1.31964706E+001, 1.75097768E-001, -1.45880486E+000
473, 1.32160818E+001, 1.74784818E-001, -1.45871016E+000
474, 1.31771815E+001, 1.73644899E-001, -1.45858760E+000
475, 1.31567098E+001, 1.14300572E-001, -1.44816660E+000
476, 1.31472815E+001, 1.71718047E-001, -1.45830816E+000
477, 1.31267856E+001, 1.69885247E-001, -1.45802636E+000
478, 1.31062948E+001, 1.69789268E-001, -1.45805073E+000
479, 1.31368298E+001, 1.13453416E-001, -1.44805731E+000
480, 1.31764560E+001, 1.14788449E-001, -1.44821281E+000
481, 1.30778207E+001, 1.59602336E-001, -1.45631219E+000
482, 1.31060811E+001, 1.14243245E-001, -1.44825853E+000
483, 1.30785148E+001, 1.39115121E-001, -1.45269895E+000
484, 1.30765050E+001, 1.19439198E-001, -1.44923418E+000
485, 1.30738790E+001, 1.11015922E-001, -1.44775447E+000
486, 1.30779608E+001, 1.29098047E-001, -1.45093408E+000
487, 1.30778608E+001, 1.70216282E-001, -1.45818333E+000
488, 1.30952598E+001, 1.12563939E-001, -1.44798429E+000
489, 1.35303622E+001, 1.48252591E-001, -1.45339914E+000
490, 1.31469967E+001, 1.13437844E-001, -1.44803408E+000
491, 1.30840293E+001, 1.10039330E-001, -1.44756184E+000
492, 1.31268390E+001, 1.14444916E-001, -1.44825225E+000
493, 1.31664261E+001, 1.14321059E-001, -1.44815062E+000
494, 1.30782202E+001, 1.49293099E-001, -1.45449389E+000
495, 1.31961703E+001, 1.16304322E-001, -1.44844032E+000
496, 1.32163395E+001, 1.16127525E-001, -1.44836850E+000
497, 1.32363871E+001, 1.16702653E-001, -1.44842948E+000
498, 1.32562454E+001, 1.16920517E-001, -1.44842787E+000
499, 1.32739001E+001, 1.18447503E-001, -1.44866149E+000
500, 1.32937336E+001, 1.20776312E-001, -1.44903208E+000
501, 1.33135656E+001, 1.23352742E-001, -1.44944632E+000
502, 1.33337193E+001, 1.23835519E-001, -1.44949081E+000
503, 1.33534684E+001, 1.22869080E-001, -1.44928063E+000
504, 1.33729677E+001, 1.25427684E-001, -1.44969240E+000
505, 1.33926970E+001, 1.27701533E-001, -1.45005351E+000
506, 1.34127556E+001, 1.28391813E-001, -1.45013478E+000
507, 1.34323186E+001, 1.30158382E-001, -1.45040679E+000
508, 1.34517668E+001, 1.34794707E-001, -1.45118496E+000
509, 1.34723272E+001, 1.35500796E-001, -1.45126800E+000
510, 1.34902544E+001, 1.37116537E-001, -1.45151672E+000
511, 1.35114572E+001, 1.39328489E-001, -1.45186395E+000
512, 1.34630827E+001, 1.71073569E-001, -1.45755803E+000
513, 1.34429138E+001, 1.70926207E-001, -1.45757271E+000
514, 1.34828944E+001, 1.71113882E-001, -1.45752521E+000
515, 1.35108238E+001, 1.69932411E-001, -1.45726063E+000
516, 1.35327193E+001, 1.68143780E-001, -1.45690116E+000
517, 1.34918416E+001, 1.73554929E-001, -1.45793753E+000
518, 1.35318180E+001, 1.38380286E-001, -1.45165575E+000
519, 1.33234046E+001, 1.74336797E-001, -1.45841486E+000
520, 1.34230926E+001, 1.73455347E-001, -1.45805854E+000
521, 1.34033656E+001, 1.73637848E-001, -1.45813047E+000
522, 1.33838973E+001, 1.75043560E-001, -1.45841753E+000
523, 1.33640546E+001, 1.73946571E-001, -1.45826413E+000
524, 1.33439458E+001, 1.73577358E-001, -1.45823957E+000
525, 1.35263732E+001, 1.58524265E-001, -1.45521806E+000
526, 1.33044298E+001, 1.77649955E-001, -1.45903721E+000
527, 1.32852530E+001, 1.73790957E-001, -1.45839553E+000
528, 1.32652237E+001, 1.77034075E-001, -1.45900765E+000
529, 1.32455214E+001, 1.75647265E-001, -1.45880287E+000
530, 1.31162756E+001, 1.69163881E-001, -1.45792036E+000
531, 1.31571527E+001, 1.72440592E-001, -1.45841565E+000
532, 1.31371822E+001, 1.70896897E-001, -1.45818375E+000
533, 1.32465136E+001, 1.16850395E-001, -1.44843512E+000
534, 1.31165430E+001, 1.14854900E-001, -1.44834528E+000
535, 1.32062010E+001, 1.16276729E-001, -1.44841524E+000
536, 1.31861983E+001, 1.15841693E-001, -1.44837886E+000
537, 1.32263533E+001, 1.16333479E-001, -1.44838462E+000
538, 1.32652809E+001, 1.15478051E-001, -1.44815535E+000
539, 1.32836043E+001, 1.19519301E-001, -1.44883088E+000
540, 1.33035343E+001, 1.22388208E-001, -1.44929650E+000
541, 1.33236351E+001, 1.23847267E-001, -1.44951321E+000
542, 1.33436729E+001, 1.23539540E-001, -1.44941857E+000
543, 1.33632782E+001, 1.23593586E-001, -1.44938858E+000
544, 1.33827543E+001, 1.26771265E-001, -1.44990955E+000
545, 1.34028829E+001, 1.28196199E-001, -1.45012019E+000
546, 1.34224250E+001, 1.28621133E-001, -1.45015572E+000
547, 1.34418162E+001, 1.32821073E-001, -1.45085707E+000
548, 1.34622084E+001, 1.35891693E-001, -1.45135731E+000
549, 1.34814856E+001, 1.33447507E-001, -1.45088756E+000
550, 1.35007394E+001, 1.38891649E-001, -1.45180854E+000
551, 1.35221801E+001, 1.39372516E-001, -1.45185010E+000
552, 1.32259012E+001, 1.75514429E-001, -1.45881900E+000
553, 1.30870492E+001, 1.73873974E-001, -1.45880965E+000
554, 1.32359189E+001, 1.76005981E-001, -1.45888546E+000
555, 1.34350595E+001, 1.43166764E-001, -1.45269461E+000
556, 1.33791783E+001, 1.65330506E-001, -1.45671466E+000
557, 1.30897062E+001, 1.32811235E-001, -1.45156503E+000
558, 1.32511978E+001, 1.64035442E-001, -1.45674429E+000
559, 1.33495637E+001, 1.60491925E-001, -1.45592132E+000
560, 1.33601075E+001, 1.60828040E-001, -1.45595932E+000
561, 1.33165289E+001, 1.62177054E-001, -1.45628498E+000
562, 1.32781630E+001, 1.59081263E-001, -1.45581653E+000
563, 1.32911955E+001, 1.60496124E-001, -1.45603970E+000
564, 1.31321635E+001, 1.59093463E-001, -1.45611295E+000
565, 1.30884043E+001, 1.54510737E-001, -1.45539322E+000
566, 1.32602861E+001, 1.67406800E-001, -1.45732034E+000
567, 1.35063595E+001, 1.49563280E-001, -1.45367859E+000
568, 1.31426775E+001, 1.59502364E-001, -1.45616385E+000
569, 1.31529268E+001, 1.60238029E-001, -1.45627289E+000
570, 1.31093745E+001, 1.55260143E-001, -1.45548308E+000
571, 1.33702354E+001, 1.62474394E-001, -1.45622916E+000
572, 1.31904550E+001, 1.27965567E-001, -1.45050769E+000
573, 1.30962020E+001, 1.71882070E-001, -1.45844003E+000
574, 1.33278083E+001, 1.61489638E-001, -1.45614106E+000
575, 1.33575619E+001, 1.33031175E-001, -1.45106393E+000
576, 1.31207905E+001, 1.57447868E-001, -1.45584576E+000
577, 1.31800814E+001, 1.27191879E-001, -1.45039220E+000
578, 1.30877604E+001, 1.64592624E-001, -1.45717194E+000
579, 1.34800629E+001, 1.58124395E-001, -1.45524090E+000
580, 1.31105421E+001, 1.27193326E-001, -1.45053261E+000
581, 1.31327146E+001, 1.25464903E-001, -1.45018320E+000
582, 1.30894736E+001, 1.43737890E-001, -1.45349184E+000
583, 1.30988861E+001, 1.24804193E-001, -1.45013490E+000
584, 1.31629045E+001, 1.61576798E-001, -1.45648880E+000
585, 1.32109929E+001, 1.27439743E-001, -1.45037359E+000
586, 1.33280032E+001, 1.36414941E-001, -1.45172006E+000
587, 1.32529846E+001, 1.28239148E-001, -1.45042989E+000
588, 1.34074924E+001, 1.39704823E-001, -1.45213984E+000
589, 1.33068178E+001, 1.35759054E-001, -1.45164713E+000
590, 1.32963281E+001, 1.34059291E-001, -1.45136860E+000
591, 1.33866251E+001, 1.39475206E-001, -1.45214142E+000
592, 1.33174079E+001, 1.36421358E-001, -1.45174254E+000
593, 1.34264903E+001, 1.38757983E-001, -1.45193463E+000
594, 1.33762562E+001, 1.38579263E-001, -1.45200437E+000
595, 1.33971697E+001, 1.39581787E-001, -1.45213896E+000
596, 1.34174232E+001, 1.39782791E-001, -1.45213357E+000
597, 1.31218795E+001, 1.27108358E-001, -1.45049478E+000
598, 1.34560272E+001, 1.47206371E-001, -1.45336452E+000
599, 1.34807673E+001, 1.44585835E-001, -1.45285266E+000
600, 1.34930189E+001, 1.50192726E-001, -1.45381645E+000
601, 1.32419213E+001, 1.28037383E-001, -1.45041662E+000
602, 1.33881524E+001, 1.63118206E-001, -1.45630655E+000
603, 1.32112213E+001, 1.63121452E-001, -1.45666373E+000
604, 1.34181408E+001, 1.62106523E-001, -1.45606775E+000
605, 1.34483720E+001, 1.58474422E-001, -1.45536648E+000
606, 1.33980032E+001, 1.62402395E-001, -1.45616050E+000
607, 1.34080884E+001, 1.62151058E-001, -1.45609586E+000
608, 1.32648810E+001, 1.28193370E-001, -1.45039784E+000
609, 1.33041598E+001, 1.63773404E-001, -1.45659135E+000
610, 1.35143606E+001, 1.59390474E-001, -1.45539498E+000
611, 1.33383907E+001, 1.36093503E-001, -1.45164245E+000
612, 1.33387509E+001, 1.60955411E-001, -1.45602482E+000
613, 1.32691475E+001, 1.66047957E-001, -1.45706291E+000
614, 1.31830741E+001, 1.62337766E-001, -1.45658230E+000
615, 1.31731159E+001, 1.62285369E-001, -1.45659313E+000
616, 1.31614517E+001, 1.26061798E-001, -1.45023051E+000
617, 1.34451284E+001, 1.45806820E-001, -1.45313975E+000
618, 1.32870406E+001, 1.30255594E-001, -1.45071674E+000
619, 1.30982849E+001, 1.61011761E-001, -1.45651943E+000
620, 1.31512762E+001, 1.25264348E-001, -1.45011043E+000
621, 1.35183991E+001, 1.49256129E-001, -1.45360018E+000
622, 1.31420069E+001, 1.22851477E-001, -1.44970373E+000
623, 1.32008360E+001, 1.28095200E-001, -1.45050962E+000
624, 1.31708832E+001, 1.24420794E-001, -1.44992220E+000
625, 1.32214017E+001, 1.27510018E-001, -1.45036500E+000
626, 1.32407104E+001, 1.63577333E-001, -1.45668467E+000
627, 1.32767613E+001, 1.31044033E-001, -1.45087646E+000
628, 1.33484482E+001, 1.35263498E-001, -1.45147585E+000
629, 1.33663016E+001, 1.36437509E-001, -1.45164684E+000
630, 1.32315858E+001, 1.28287127E-001, -1.45048148E+000
631, 1.34685079E+001, 1.48659486E-001, -1.45359555E+000
632, 1.34276382E+001, 1.62952613E-001, -1.45619777E+000
633, 1.34371184E+001, 1.57553180E-001, -1.45522675E+000
634, 1.34591475E+001, 1.59238065E-001, -1.45547939E+000
635, 1.32216280E+001, 1.63117034E-001, -1.45664198E+000
636, 1.30873841E+001, 1.21518505E-001, -1.44957883E+000
637, 1.32019454E+001, 1.65662526E-001, -1.45713041E+000
638, 1.31929762E+001, 1.63186164E-001, -1.45671191E+000
639, 1.32583612E+001, 1.41083413E-001, -1.45268346E+000
640, 1.31298022E+001, 1.37328608E-001, -1.45228062E+000
641, 1.31027125E+001, 1.38863641E-001, -1.45260584E+000
642, 1.31837056E+001, 1.39209165E-001, -1.45250351E+000
643, 1.34915933E+001, 1.63055398E-001, -1.45608698E+000
644, 1.33221108E+001, 1.49150958E-001, -1.45397726E+000
645, 1.32162264E+001, 1.37345838E-001, -1.45210946E+000
646, 1.31485261E+001, 1.47846989E-001, -1.45409724E+000
647, 1.32622076E+001, 1.55025690E-001, -1.45513370E+000
648, 1.32853493E+001, 1.44072146E-001, -1.45315598E+000
649, 1.35027379E+001, 1.60208385E-001, -1.45556260E+000
650, 1.32064655E+001, 1.39882713E-001, -1.45257638E+000
651, 1.31593539E+001, 1.49044040E-001, -1.45428646E+000
652, 1.33564023E+001, 1.46396911E-001, -1.45342262E+000
653, 1.31166633E+001, 1.41605764E-001, -1.45306115E+000
654, 1.32986675E+001, 1.48002245E-001, -1.45382200E+000
655, 1.33798876E+001, 1.52552425E-001, -1.45446048E+000
656, 1.31954382E+001, 1.40046176E-001, -1.45262743E+000
657, 1.33105940E+001, 1.49305616E-001, -1.45402774E+000
658, 1.34690777E+001, 1.61144320E-001, -1.45579545E+000
659, 1.32475882E+001, 1.38092072E-001, -1.45217781E+000
660, 1.32311387E+001, 1.65921025E-001, -1.45711714E+000
661, 1.32711049E+001, 1.43449804E-001, -1.45307497E+000
662, 1.33917052E+001, 1.51257827E-001, -1.45420843E+000
663, 1.33332501E+001, 1.48742399E-001, -1.45388278E+000
664, 1.34251501E+001, 1.50832157E-001, -1.45406597E+000
665, 1.33681329E+001, 1.49533899E-001, -1.45395202E+000
666, 1.31688131E+001, 1.51985026E-001, -1.45478588E+000
667, 1.31375979E+001, 1.47618363E-001, -1.45407896E+000
668, 1.30982363E+001, 1.50296356E-001, -1.45463042E+000
669, 1.34133783E+001, 1.50935178E-001, -1.45410786E+000
670, 1.33444360E+001, 1.48054128E-001, -1.45373890E+000
671, 1.32261202E+001, 1.40035815E-001, -1.45256376E+000
672, 1.34025730E+001, 1.50977189E-001, -1.45413705E+000
673, 1.32372529E+001, 1.40328709E-001, -1.45259296E+000
674, 1.32164742E+001, 1.50211906E-001, -1.45437722E+000
675, 1.31786278E+001, 1.50540300E-001, -1.45451140E+000
676, 1.31698208E+001, 1.38201320E-001, -1.45235381E+000
677, 1.31271032E+001, 1.48431712E-001, -1.45424351E+000
678, 1.32022833E+001, 1.52976404E-001, -1.45489320E+000
679, 1.31897396E+001, 1.51230541E-001, -1.45461069E+000
680, 1.31425467E+001, 1.35132897E-001, -1.45186783E+000
681, 1.32469791E+001, 1.50987322E-001, -1.45445244E+000
682, 1.31556039E+001, 1.37047732E-001, -1.45217909E+000
683, 1.32314846E+001, 1.53088949E-001, -1.45485418E+000
684, 1.35430454E+001, 1.13419167E-001, -1.45148722E+000
685, 1.35331259E+001, 1.12190601E-001, -1.45128172E+000
686, 1.35233439E+001, 1.10983714E-001, -1.45106831E+000
687, 1.35136182E+001, 1.09614908E-001, -1.45097942E+000
688, 1.35044065E+001, 1.08152668E-001, -1.45102907E+000
689, 1.34881087E+001, 1.06198583E-001, -1.45061214E+000
690, 1.34787095E+001, 1.05328946E-001, -1.45017897E+000
691, 1.34691292E+001, 1.04473034E-001, -1.44973883E+000
692, 1.34589002E+001, 1.03199047E-001, -1.44954425E+000
693, 1.34492847E+001, 1.01887780E-001, -1.44945895E+000
694, 1.34394813E+001, 1.00638400E-001, -1.44933065E+000
695, 1.34295872E+001, 9.95082862E-002, -1.44913027E+000
696, 1.34196986E+001, 9.84197177E-002, -1.44892897E+000
697, 1.34098469E+001, 9.73280262E-002, -1.44876525E+000
698, 1.33999980E+001, 9.62839603E-002, -1.44860066E+000
699, 1.33901402E+001, 9.53033629E-002, -1.44842431E+000
700, 1.33802407E+001, 9.43193839E-002, -1.44828363E+000
701, 1.33703423E+001, 9.34407406E-002, -1.44810403E+000
702, 1.33604374E+001, 9.25385591E-002, -1.44797936E+000
703, 1.33504920E+001, 9.17155895E-002, -1.44783254E+000
704, 1.33405647E+001, 9.09061363E-002, -1.44771575E+000
705, 1.33307173E+001, 9.01192097E-002, -1.44762598E+000
706, 1.33207982E+001, 8.90806634E-002, -1.44776065E+000
707, 1.33108119E+001, 8.83996600E-002, -1.44765946E+000
708, 1.33008797E+001, 8.77589574E-002, -1.44756872E+000
709, 1.32909514E+001, 8.75319648E-002, -1.44720387E+000
710, 1.32810428E+001, 8.69664629E-002, -1.44713078E+000
711, 1.32711294E+001, 8.65217517E-002, -1.44700456E+000
712, 1.32612569E+001, 8.59849476E-002, -1.44697854E+000
713, 1.32514632E+001, 8.55808241E-002, -1.44689072E+000
714, 1.32417661E+001, 8.51216458E-002, -1.44687716E+000
715, 1.32315049E+001, 8.45675934E-002, -1.44694936E+000
716, 1.32212184E+001, 8.39804112E-002, -1.44708692E+000
717, 1.32114413E+001, 8.38485681E-002, -1.44691436E+000
718, 1.32015948E+001, 8.38511797E-002, -1.44666276E+000
719, 1.31916635E+001, 8.36351359E-002, -1.44658495E+000
720, 1.31817242E+001, 8.33625520E-002, -1.44655867E+000
721, 1.31718328E+001, 8.31565097E-002, -1.44649711E+000
722, 1.31619087E+001, 8.28631334E-002, -1.44650553E+000
723, 1.31519758E+001, 8.26972510E-002, -1.44643570E+000
724, 1.31421040E+001, 8.24478512E-002, -1.44643854E+000
725, 1.31322185E+001, 8.22851958E-002, -1.44639632E+000
726, 1.31222486E+001, 8.20598860E-002, -1.44641483E+000
727, 1.31123758E+001, 8.19326000E-002, -1.44638720E+000
728, 1.31027141E+001, 8.18380440E-002, -1.44636193E+000
729, 1.30934830E+001, 8.19914414E-002, -1.44619643E+000
730, 1.34966461E+001, 1.05852286E-001, -1.45211689E+000
731, 1.30466065E+001, 9.95007798E-002, -1.46625996E+000
732, 1.30466050E+001, 9.38989824E-002, -1.47456095E+000
733, 1.30466031E+001, 9.21190756E-002, -1.48438433E+000
734, 1.30466012E+001, 8.90948714E-002, -1.49430715E+000
735, 1.30466008E+001, 1.02541134E-001, -1.49493554E+000
736, 1.30465997E+001, 1.19109876E-001, -1.49894568E+000
737, 1.30465989E+001, 1.35018880E-001, -1.50155480E+000
738, 1.30465979E+001, 1.50923194E-001, -1.50464642E+000
739, 1.30465971E+001, 1.68979746E-001, -1.50688298E+000
740, 1.30465990E+001, 1.75058118E-001, -1.49671740E+000
741, 1.30466006E+001, 1.79363731E-001, -1.48823966E+000
742, 1.30466022E+001, 1.78660188E-001, -1.48018452E+000
743, 1.30466025E+001, 1.68730879E-001, -1.47926315E+000
744, 1.30466032E+001, 1.59348962E-001, -1.47709631E+000
745, 1.30466038E+001, 1.49426217E-001, -1.47494957E+000
746, 1.30466043E+001, 1.40282369E-001, -1.47337617E+000
747, 1.30466048E+001, 1.30174915E-001, -1.47188641E+000
748, 1.30466053E+001, 1.20366178E-001, -1.47037870E+000
749, 1.30466059E+001, 1.10876605E-001, -1.46809326E+000
750, 1.30466031E+001, 1.03175784E-001, -1.48343001E+000
751, 1.30466019E+001, 1.15047433E-001, -1.48829674E+000
752, 1.30466011E+001, 1.30422434E-001, -1.49052991E+000
753, 1.30466002E+001, 1.47429978E-001, -1.49362750E+000
754, 1.30465992E+001, 1.62071739E-001, -1.49697029E+000
755, 1.30466008E+001, 1.70207344E-001, -1.48821751E+000
756, 1.30466012E+001, 1.60074490E-001, -1.48705814E+000
757, 1.30466021E+001, 1.51498011E-001, -1.48352279E+000
758, 1.30466023E+001, 1.41818839E-001, -1.48356525E+000
759, 1.30466031E+001, 1.32999595E-001, -1.48037584E+000
760, 1.30466032E+001, 1.23219844E-001, -1.48040045E+000
761, 1.30466048E+001, 1.03917908E-001, -1.47430368E+000
762, 1.30466040E+001, 1.13051993E-001, -1.47784504E+000
763, 1.30651615E+001, 1.97126502E-001, -1.49751267E+000
764, 1.30686083E+001, 1.98576512E-001, -1.48680278E+000
765, 1.30803325E+001, 1.99462281E-001, -1.48615511E+000
766, 1.31011735E+001, 2.00824211E-001, -1.48569992E+000
767, 1.31212672E+001, 2.01837775E-001, -1.48655815E+000
768, 1.31413263E+001, 2.02907715E-001, -1.48568184E+000
769, 1.31611430E+001, 2.03696848E-001, -1.48603805E+000
770, 1.31810532E+001, 2.04327294E-001, -1.48674705E+000
771, 1.32007482E+001, 2.05092345E-001, -1.48502483E+000
772, 1.32203787E+001, 2.05371899E-001, -1.48676323E+000
773, 1.32402899E+001, 2.05800416E-001, -1.48607370E+000
774, 1.32601083E+001, 2.06075748E-001, -1.48576804E+000
775, 1.32800968E+001, 2.06117022E-001, -1.48675683E+000
776, 1.33001420E+001, 2.06215450E-001, -1.48606518E+000
777, 1.33204135E+001, 2.06084577E-001, -1.48661561E+000
778, 1.33403225E+001, 2.05986043E-001, -1.48565450E+000
779, 1.33600847E+001, 2.05746871E-001, -1.48501050E+000
780, 1.33800637E+001, 2.05277917E-001, -1.48563281E+000
781, 1.34003105E+001, 2.04792305E-001, -1.48503046E+000
782, 1.34194797E+001, 2.04308893E-001, -1.48337790E+000
783, 1.34390602E+001, 2.03368373E-001, -1.48569298E+000
784, 1.34591658E+001, 2.02605201E-001, -1.48412088E+000
785, 1.34790188E+001, 2.01629490E-001, -1.48373483E+000
786, 1.34982534E+001, 2.00524717E-001, -1.48382252E+000
787, 1.35177411E+001, 1.99315895E-001, -1.48339031E+000
788, 1.35371432E+001, 1.97912293E-001, -1.48379858E+000
789, 1.35459179E+001, 1.97341529E-001, -1.48250047E+000
790, 1.35456001E+001, 1.95536832E-001, -1.50529311E+000
791, 1.35454116E+001, 1.94924790E-001, -1.51352972E+000
792, 1.35201227E+001, 1.97249104E-001, -1.50683683E+000
793, 1.34874614E+001, 1.99084220E-001, -1.50892053E+000
794, 1.34545456E+001, 2.00673714E-001, -1.50961527E+000
795, 1.34260951E+001, 2.01791049E-001, -1.50991863E+000
796, 1.33961218E+001, 2.02841860E-001, -1.50849111E+000
797, 1.33650458E+001, 2.03540928E-001, -1.50839092E+000
798, 1.33337174E+001, 2.03762133E-001, -1.51069199E+000
799, 1.33051938E+001, 2.04020577E-001, -1.50923896E+000
800, 1.32766444E+001, 2.03787069E-001, -1.51090990E+000
801, 1.32454287E+001, 2.03603033E-001, -1.50899577E+000
802, 1.32158391E+001, 2.02860792E-001, -1.51072729E+000
803, 1.31833717E+001, 2.01924629E-001, -1.51076316E+000
804, 1.31541658E+001, 2.01004419E-001, -1.50882740E+000
805, 1.31226022E+001, 1.99339361E-001, -1.51063752E+000
806, 1.30943633E+001, 1.97935886E-001, -1.50859315E+000
807, 1.30672728E+001, 1.96197167E-001, -1.50791972E+000
808, 1.31111726E+001, 2.01303947E-001, -1.48649773E+000
809, 1.30907555E+001, 2.00225748E-001, -1.48539185E+000
810, 1.31311845E+001, 2.02409793E-001, -1.48589630E+000
811, 1.31510125E+001, 2.03322388E-001, -1.48573693E+000
812, 1.31710410E+001, 2.03979746E-001, -1.48680583E+000
813, 1.31907695E+001, 2.04738703E-001, -1.48572787E+000
814, 1.32106877E+001, 2.05262742E-001, -1.48575655E+000
815, 1.32303568E+001, 2.05557557E-001, -1.48683914E+000
816, 1.32504125E+001, 2.05963319E-001, -1.48583243E+000
817, 1.32702119E+001, 2.06130977E-001, -1.48605152E+000
818, 1.32901489E+001, 2.06145568E-001, -1.48676866E+000
819, 1.33104313E+001, 2.06191278E-001, -1.48604280E+000
820, 1.33304753E+001, 2.06011313E-001, -1.48653663E+000
821, 1.33504351E+001, 2.05898381E-001, -1.48509646E+000
822, 1.33702028E+001, 2.05540016E-001, -1.48513870E+000
823, 1.33900265E+001, 2.05066955E-001, -1.48518981E+000
824, 1.34103243E+001, 2.04462711E-001, -1.48525227E+000
825, 1.34287425E+001, 2.03798994E-001, -1.48542410E+000
826, 1.34493581E+001, 2.02960155E-001, -1.48530376E+000
827, 1.34691130E+001, 2.02185437E-001, -1.48325347E+000
828, 1.34885770E+001, 2.01047416E-001, -1.48440144E+000
829, 1.35082162E+001, 1.99927770E-001, -1.48354625E+000
830, 1.35275361E+001, 1.98629403E-001, -1.48353423E+000
831, 1.35431437E+001, 1.96611188E-001, -1.49457597E+000
832, 1.34704158E+001, 2.00202016E-001, -1.50613920E+000
833, 1.35347688E+001, 1.96090256E-001, -1.50857339E+000
834, 1.35033787E+001, 1.98297439E-001, -1.50714165E+000
835, 1.34403170E+001, 2.01229543E-001, -1.51020639E+000
836, 1.34117540E+001, 2.02288114E-001, -1.50971614E+000
837, 1.33806392E+001, 2.03091061E-001, -1.51007681E+000
838, 1.33483607E+001, 2.03787144E-001, -1.50850346E+000
839, 1.33198715E+001, 2.03841299E-001, -1.51086267E+000
840, 1.32904714E+001, 2.03853884E-001, -1.51097041E+000
841, 1.32620662E+001, 2.03831872E-001, -1.50890223E+000
842, 1.32301010E+001, 2.03151556E-001, -1.51098242E+000
843, 1.31999589E+001, 2.02733439E-001, -1.50763051E+000
844, 1.31690695E+001, 2.01408675E-001, -1.51082913E+000
845, 1.31375334E+001, 2.00266796E-001, -1.50875047E+000
846, 1.31086848E+001, 1.98592847E-001, -1.51052390E+000
847, 1.30797966E+001, 1.96867413E-001, -1.50992415E+000
848, 1.31460600E+001, 2.01808887E-001, -1.49750791E+000
849, 1.31050676E+001, 1.99663249E-001, -1.49808337E+000
850, 1.34194292E+001, 2.03204111E-001, -1.49615345E+000
851, 1.30954713E+001, 1.99384502E-001, -1.49539867E+000
852, 1.31365129E+001, 2.01582318E-001, -1.49556914E+000
853, 1.31651545E+001, 2.02493906E-001, -1.49846741E+000
854, 1.31556383E+001, 2.02414283E-001, -1.49567400E+000
855, 1.31871400E+001, 2.03277171E-001, -1.49831073E+000
856, 1.31761495E+001, 2.02832803E-001, -1.49907267E+000
857, 1.32048602E+001, 2.04168991E-001, -1.49468700E+000
858, 1.31961366E+001, 2.03928333E-001, -1.49470471E+000
859, 1.32244896E+001, 2.04169504E-001, -1.49911075E+000
860, 1.32136329E+001, 2.04008980E-001, -1.49831477E+000
861, 1.32452294E+001, 2.04877436E-001, -1.49576489E+000
862, 1.32355132E+001, 2.04434783E-001, -1.49857382E+000
863, 1.32643470E+001, 2.05115486E-001, -1.49568792E+000
864, 1.32547083E+001, 2.04813604E-001, -1.49764925E+000
865, 1.32845417E+001, 2.04915322E-001, -1.49909059E+000
866, 1.32736766E+001, 2.04911385E-001, -1.49850481E+000
867, 1.33052644E+001, 2.05244493E-001, -1.49598885E+000
868, 1.32955004E+001, 2.04995884E-001, -1.49856387E+000
869, 1.33259770E+001, 2.04872763E-001, -1.49890237E+000
870, 1.33150176E+001, 2.04974672E-001, -1.49848360E+000
871, 1.33461954E+001, 2.05020627E-001, -1.49519681E+000
872, 1.33368603E+001, 2.04845305E-001, -1.49819389E+000
873, 1.33652784E+001, 2.04740165E-001, -1.49497593E+000
874, 1.33558251E+001, 2.04709791E-001, -1.49702787E+000
875, 1.33858673E+001, 2.04052483E-001, -1.49764642E+000
876, 1.33749867E+001, 2.04301597E-001, -1.49762594E+000
877, 1.34063862E+001, 2.03529401E-001, -1.49723070E+000
878, 1.33958493E+001, 2.04021505E-001, -1.49516264E+000
879, 1.34450226E+001, 2.02065807E-001, -1.49796018E+000
880, 1.34328234E+001, 2.02561875E-001, -1.49789711E+000
881, 1.34651056E+001, 2.01576355E-001, -1.49310250E+000
882, 1.34562460E+001, 2.01664688E-001, -1.49691767E+000
883, 1.34828601E+001, 2.00382787E-001, -1.49635803E+000
884, 1.34738411E+001, 2.01152615E-001, -1.49293264E+000
885, 1.35031190E+001, 1.99440068E-001, -1.49364301E+000
886, 1.34935249E+001, 1.99777965E-001, -1.49642729E+000
887, 1.35220982E+001, 1.98230724E-001, -1.49338355E+000
888, 1.35125482E+001, 1.98688950E-001, -1.49551127E+000
889, 1.30750672E+001, 1.97795709E-001, -1.49781430E+000
890, 1.31269507E+001, 2.00821793E-001, -1.49829899E+000
891, 1.35316539E+001, 1.97363350E-001, -1.49577223E+000
892, 1.31159935E+001, 2.00197129E-001, -1.49879697E+000
893, 1.30856770E+001, 1.98518099E-001, -1.49769088E+000
894, 1.30498428E+001, 1.73841854E-001, -1.46219639E+000
895, 1.30498389E+001, 1.63597119E-001, -1.46039399E+000
896, 1.30498381E+001, 1.53794245E-001, -1.45866475E+000
897, 1.30498442E+001, 1.44074538E-001, -1.45694169E+000
898, 1.30498508E+001, 1.34377945E-001, -1.45522085E+000
899, 1.30498557E+001, 1.24701642E-001, -1.45350408E+000
900, 1.30498518E+001, 1.15089359E-001, -1.45180649E+000
901, 1.30498400E+001, 1.05770332E-001, -1.45016803E+000
902, 1.30497885E+001, 9.73545572E-002, -1.44872946E+000
903, 1.30683027E+001, 7.07128124E-002, -1.48554469E+000
904, 1.30806089E+001, 7.04713505E-002, -1.48753056E+000
905, 1.31072973E+001, 7.08185394E-002, -1.48731473E+000
906, 1.31388348E+001, 7.14129283E-002, -1.48746073E+000
907, 1.31689803E+001, 7.23129235E-002, -1.48698624E+000
908, 1.31991639E+001, 7.31794598E-002, -1.48803962E+000
909, 1.32291404E+001, 7.43581729E-002, -1.48820825E+000
910, 1.32602829E+001, 7.63478374E-002, -1.48450139E+000
911, 1.32902520E+001, 7.75045388E-002, -1.48898956E+000
912, 1.33196987E+001, 7.95486871E-002, -1.48941210E+000
913, 1.33496463E+001, 8.19895221E-002, -1.48977953E+000
914, 1.33803865E+001, 8.49302819E-002, -1.48971431E+000
915, 1.34115380E+001, 8.84073235E-002, -1.48894150E+000
916, 1.34424683E+001, 9.21125687E-002, -1.48929248E+000
917, 1.34718458E+001, 9.56054415E-002, -1.49200052E+000
918, 1.35000366E+001, 9.92489916E-002, -1.49290799E+000
919, 1.35321431E+001, 1.03600051E-001, -1.49272872E+000
920, 1.35385346E+001, 1.05618079E-001, -1.48038370E+000
921, 1.35391342E+001, 1.06855242E-001, -1.46893017E+000
922, 1.35190299E+001, 1.04172248E-001, -1.46921248E+000
923, 1.34980781E+001, 1.01398238E-001, -1.46969505E+000
924, 1.34772436E+001, 9.87835409E-002, -1.46929640E+000
925, 1.34589669E+001, 9.65726409E-002, -1.46861760E+000
926, 1.34394625E+001, 9.36809924E-002, -1.47277503E+000
927, 1.34173751E+001, 9.11194726E-002, -1.47225792E+000
928, 1.33984968E+001, 8.95981676E-002, -1.46765729E+000
929, 1.33797199E+001, 8.77211061E-002, -1.46722692E+000
930, 1.33609173E+001, 8.59188266E-002, -1.46742206E+000
931, 1.33407632E+001, 8.45040293E-002, -1.46506952E+000
932, 1.33205993E+001, 8.26984998E-002, -1.46675053E+000
933, 1.33015736E+001, 8.14282162E-002, -1.46630905E+000
934, 1.32812550E+001, 8.03959655E-002, -1.46479408E+000
935, 1.32599129E+001, 7.88156728E-002, -1.46776345E+000
936, 1.32409201E+001, 7.83794422E-002, -1.46500789E+000
937, 1.32212303E+001, 7.79048812E-002, -1.46321318E+000
938, 1.32010999E+001, 7.69082961E-002, -1.46515655E+000
939, 1.31820344E+001, 7.64008566E-002, -1.46468119E+000
940, 1.31616034E+001, 7.48266922E-002, -1.47047343E+000
941, 1.31408319E+001, 7.53419580E-002, -1.46455894E+000
942, 1.31219748E+001, 7.50072774E-002, -1.46436317E+000
943, 1.31031678E+001, 7.45661403E-002, -1.46533051E+000
944, 1.30812875E+001, 7.43145583E-002, -1.46566958E+000
945, 1.30695695E+001, 7.42566538E-002, -1.46570942E+000
946, 1.30659483E+001, 7.22584728E-002, -1.47650800E+000
947, 1.30937879E+001, 7.05631376E-002, -1.48777496E+000
948, 1.31231631E+001, 7.10957634E-002, -1.48731180E+000
949, 1.31542573E+001, 7.18974694E-002, -1.48689151E+000
950, 1.31842337E+001, 7.26982374E-002, -1.48770966E+000
951, 1.32142952E+001, 7.37418845E-002, -1.48818286E+000
952, 1.32442396E+001, 7.50828880E-002, -1.48791262E+000
953, 1.32754328E+001, 7.68283846E-002, -1.48716236E+000
954, 1.33050067E+001, 7.84877663E-002, -1.48917720E+000
955, 1.33347759E+001, 8.07374254E-002, -1.48956330E+000
956, 1.33649374E+001, 8.33842875E-002, -1.48989789E+000
957, 1.33959209E+001, 8.65337748E-002, -1.48999727E+000
958, 1.34273602E+001, 9.06541731E-002, -1.48569851E+000
959, 1.34574128E+001, 9.38097166E-002, -1.49120099E+000
960, 1.34859983E+001, 9.73963724E-002, -1.49275327E+000
961, 1.35154027E+001, 1.01451136E-001, -1.49140596E+000
962, 1.35292712E+001, 1.05458479E-001, -1.46978444E+000
963, 1.35085871E+001, 1.02807094E-001, -1.46924189E+000
964, 1.34873641E+001, 9.99862946E-002, -1.47003614E+000
965, 1.34679838E+001, 9.78686961E-002, -1.46712620E+000
966, 1.34493520E+001, 9.54977688E-002, -1.46769277E+000
967, 1.34285746E+001, 9.27769251E-002, -1.46946999E+000
968, 1.34083964E+001, 9.07776668E-002, -1.46689569E+000
969, 1.33892383E+001, 8.88820129E-002, -1.46567745E+000
970, 1.33704447E+001, 8.70658997E-002, -1.46542006E+000
971, 1.33502000E+001, 8.50346914E-002, -1.46697156E+000
972, 1.33312187E+001, 8.34650121E-002, -1.46705254E+000
973, 1.33109720E+001, 8.23556326E-002, -1.46429599E+000
974, 1.32911616E+001, 8.07492474E-002, -1.46639954E+000
975, 1.32713922E+001, 7.90064004E-002, -1.47043475E+000
976, 1.32505776E+001, 7.89993717E-002, -1.46369492E+000
977, 1.32307998E+001, 7.79563814E-002, -1.46512168E+000
978, 1.32116810E+001, 7.72453205E-002, -1.46523740E+000
979, 1.31915319E+001, 7.69724940E-002, -1.46297582E+000
980, 1.31722420E+001, 7.62227988E-002, -1.46406816E+000
981, 1.31509695E+001, 7.56522338E-002, -1.46412915E+000
982, 1.31316927E+001, 7.54943394E-002, -1.46261106E+000
983, 1.31125503E+001, 7.51433523E-002, -1.46277709E+000
984, 1.30924420E+001, 7.43696659E-002, -1.46581363E+000
985, 1.31915494E+001, 7.49723212E-002, -1.47494249E+000
986, 1.31134621E+001, 7.29831652E-002, -1.47497319E+000
987, 1.32213443E+001, 7.59881562E-002, -1.47522964E+000
988, 1.31464233E+001, 7.35787204E-002, -1.47539502E+000
989, 1.32488365E+001, 7.71955846E-002, -1.47492879E+000
990, 1.32065196E+001, 7.52382192E-002, -1.47645287E+000
991, 1.32357679E+001, 7.63908924E-002, -1.47638633E+000
992, 1.33715291E+001, 8.55979937E-002, -1.47732241E+000
993, 1.32973828E+001, 7.95199715E-002, -1.47763252E+000
994, 1.30874439E+001, 7.22003940E-002, -1.47754612E+000
995, 1.33264673E+001, 8.15570127E-002, -1.47812357E+000
996, 1.34036936E+001, 8.88363437E-002, -1.47809332E+000
997, 1.33884877E+001, 8.72849402E-002, -1.47743318E+000
998, 1.35253221E+001, 1.03798521E-001, -1.48086656E+000
999, 1.34667360E+001, 9.63653243E-002, -1.47890199E+000
1000, 1.35042907E+001, 1.00999983E-001, -1.48099301E+000
1001, 1.34802036E+001, 9.78693242E-002, -1.48092162E+000
1002, 1.33563337E+001, 8.40278890E-002, -1.47845937E+000
1003, 1.30997399E+001, 7.23856057E-002, -1.47724208E+000
1004, 1.33115892E+001, 8.06680263E-002, -1.47647948E+000
1005, 1.31310470E+001, 7.33696851E-002, -1.47459867E+000
1006, 1.30761000E+001, 7.21970431E-002, -1.47709935E+000
1007, 1.34924453E+001, 9.93987229E-002, -1.48147595E+000
1008, 1.31766051E+001, 7.44056982E-002, -1.47547471E+000
1009, 1.32841424E+001, 7.88526721E-002, -1.47642878E+000
1010, 1.34522688E+001, 9.45328312E-002, -1.47893327E+000
1011, 1.35146184E+001, 1.02614801E-001, -1.47852359E+000
1012, 1.33413019E+001, 8.29100483E-002, -1.47703182E+000
**
** Elements ++++++++++++++++++++++++++++++++++++++++++++++++
**
*Element, Type=S3, Elset=Compound-1
1, 1, 22, 132
2, 22, 23, 347
3, 24, 25, 348
4, 26, 27, 349
5, 28, 29, 350
6, 30, 31, 351
7, 32, 33, 352
8, 34, 35, 353
9, 36, 37, 354
10, 38, 39, 355
11, 40, 41, 356
12, 42, 43, 357
13, 44, 45, 358
14, 46, 47, 359
15, 48, 49, 360
16, 50, 51, 361
17, 52, 53, 362
18, 54, 55, 363
19, 56, 57, 364
20, 58, 59, 365
21, 60, 61, 366
22, 62, 63, 367
23, 64, 65, 368
24, 66, 67, 369
25, 68, 69, 370
26, 2, 71, 70
27, 371, 70, 71
28, 71, 72, 371
29, 72, 73, 372
30, 74, 75, 373
31, 76, 77, 374
32, 78, 79, 375
33, 79, 3, 376
34, 375, 79, 376
35, 3, 80, 376
36, 80, 81, 376
37, 81, 82, 377
38, 83, 84, 378
39, 85, 86, 379
40, 87, 88, 380
41, 89, 90, 381
42, 91, 92, 382
43, 93, 94, 383
44, 95, 96, 384
45, 97, 98, 385
46, 99, 100, 386
47, 101, 102, 387
48, 103, 104, 388
49, 105, 106, 389
50, 107, 108, 390
51, 109, 110, 391
52, 111, 112, 392
53, 113, 114, 393
54, 115, 116, 394
55, 117, 118, 395
56, 119, 120, 396
57, 121, 122, 397
58, 123, 124, 398
59, 125, 126, 399
60, 127, 128, 400
61, 128, 4, 401
62, 400, 128, 401
63, 4, 129, 401
64, 130, 131, 402
65, 132, 22, 347
66, 347, 23, 403
67, 23, 24, 403
68, 24, 348, 403
69, 25, 26, 404
70, 27, 28, 405
71, 29, 30, 406
72, 31, 32, 407
73, 33, 34, 408
74, 35, 36, 409
75, 37, 38, 410
76, 39, 40, 411
77, 41, 42, 412
78, 43, 44, 413
79, 45, 46, 414
80, 47, 48, 415
81, 49, 50, 416
82, 51, 52, 417
83, 53, 54, 418
84, 362, 53, 418
85, 54, 363, 418
86, 55, 56, 419
87, 57, 58, 420
88, 59, 60, 421
89, 61, 62, 422
90, 63, 64, 423
91, 65, 66, 424
92, 67, 68, 425
93, 369, 67, 425
94, 68, 370, 425
95, 70, 371, 69
96, 373, 75, 426
97, 75, 76, 426
98, 371, 72, 372
99, 73, 74, 427
100, 76, 374, 426
101, 77, 78, 428
102, 376, 81, 429
103, 375, 376, 429
104, 81, 377, 429
105, 82, 83, 430
106, 84, 85, 431
107, 86, 87, 432
108, 88, 89, 433
109, 90, 91, 434
110, 92, 93, 435
111, 94, 95, 436
112, 96, 97, 437
113, 98, 99, 438
114, 100, 101, 439
115, 102, 103, 440
116, 104, 105, 441
117, 106, 107, 442
118, 108, 109, 443
119, 110, 111, 444
120, 112, 113, 445
121, 114, 115, 446
122, 116, 117, 447
123, 118, 119, 448
124, 120, 121, 449
125, 122, 123, 450
126, 124, 125, 451
127, 126, 127, 452
128, 406, 30, 351
129, 129, 130, 453
130, 131, 132, 454
131, 25, 404, 348
132, 349, 27, 405
133, 350, 29, 406
134, 351, 31, 407
135, 352, 33, 408
136, 353, 35, 409
137, 354, 37, 410
138, 355, 39, 411
139, 356, 41, 412
140, 357, 43, 413
141, 358, 45, 414
142, 359, 47, 415
143, 360, 49, 416
144, 361, 51, 417
145, 419, 56, 364
146, 363, 55, 419
147, 364, 57, 420
148, 365, 59, 421
149, 366, 61, 422
150, 367, 63, 423
151, 368, 65, 424
152, 432, 87, 380
153, 370, 69, 371
154, 73, 427, 372
155, 374, 77, 428
156, 378, 84, 431
157, 82, 430, 377
158, 380, 88, 433
159, 381, 90, 434
160, 382, 92, 435
161, 383, 94, 436
162, 384, 96, 437
163, 385, 98, 438
164, 386, 100, 439
165, 387, 102, 440
166, 388, 104, 441
167, 389, 106, 442
168, 390, 108, 443
169, 391, 110, 444
170, 392, 112, 445
171, 393, 114, 446
172, 394, 116, 447
173, 395, 118, 448
174, 396, 120, 449
175, 397, 122, 450
176, 398, 124, 451
177, 399, 126, 452
178, 402, 131, 454
179, 407, 32, 352
180, 408, 34, 353
181, 409, 36, 354
182, 410, 38, 355
183, 411, 40, 356
184, 412, 42, 357
185, 413, 44, 358
186, 414, 46, 359
187, 415, 48, 360
188, 416, 50, 361
189, 417, 52, 362
190, 421, 60, 366
191, 422, 62, 367
192, 423, 64, 368
193, 424, 66, 369
194, 434, 91, 382
195, 435, 93, 383
196, 436, 95, 384
197, 437, 97, 385
198, 438, 99, 386
199, 439, 101, 387
200, 440, 103, 388
201, 441, 105, 389
202, 442, 107, 390
203, 443, 109, 391
204, 444, 111, 392
205, 445, 113, 393
206, 446, 115, 394
207, 447, 117, 395
208, 448, 119, 396
209, 449, 121, 397
210, 450, 123, 398
211, 451, 125, 399
212, 452, 127, 400
213, 454, 132, 347
214, 405, 28, 350
215, 404, 26, 349
216, 420, 58, 365
217, 433, 89, 381
218, 427, 74, 373
219, 428, 78, 375
220, 430, 83, 378
221, 431, 85, 379
222, 86, 432, 379
223, 453, 130, 402
224, 403, 348, 455
225, 420, 365, 456
226, 350, 406, 457
227, 404, 349, 458
228, 351, 407, 459
229, 129, 453, 401
230, 352, 408, 460
231, 353, 409, 461
232, 354, 410, 462
233, 355, 411, 463
234, 356, 412, 464
235, 357, 413, 465
236, 358, 414, 466
237, 359, 415, 467
238, 360, 416, 468
239, 361, 417, 469
240, 419, 364, 470
241, 421, 366, 471
242, 364, 420, 472
243, 470, 364, 472
244, 420, 456, 472
245, 363, 419, 473
246, 419, 470, 473
247, 365, 421, 474
248, 456, 365, 474
249, 421, 471, 474
250, 433, 381, 475
251, 422, 367, 476
252, 423, 368, 477
253, 424, 369, 478
254, 432, 380, 479
255, 434, 382, 480
256, 372, 427, 481
257, 378, 431, 482
258, 373, 426, 483
259, 374, 428, 484
260, 428, 375, 485
261, 484, 428, 485
262, 375, 429, 485
263, 426, 374, 486
264, 374, 484, 486
265, 371, 372, 487
266, 370, 371, 487
267, 372, 481, 487
268, 430, 378, 488
269, 378, 482, 488
270, 453, 402, 489
271, 380, 433, 490
272, 479, 380, 490
273, 433, 475, 490
274, 377, 430, 491
275, 430, 488, 491
276, 379, 432, 492
277, 432, 479, 492
278, 381, 434, 493
279, 475, 381, 493
280, 434, 480, 493
281, 427, 373, 494
282, 373, 483, 494
283, 435, 383, 495
284, 436, 384, 496
285, 437, 385, 497
286, 438, 386, 498
287, 439, 387, 499
288, 440, 388, 500
289, 441, 389, 501
290, 442, 390, 502
291, 443, 391, 503
292, 444, 392, 504
293, 445, 393, 505
294, 446, 394, 506
295, 447, 395, 507
296, 448, 396, 508
297, 449, 397, 509
298, 450, 398, 510
299, 451, 399, 511
300, 406, 351, 512
301, 457, 406, 512
302, 351, 459, 512
303, 400, 401, 453
304, 407, 352, 513
305, 459, 407, 513
306, 352, 460, 513
307, 405, 350, 514
308, 350, 457, 514
309, 348, 404, 515
310, 455, 348, 515
311, 404, 458, 515
312, 347, 403, 516
313, 454, 347, 516
314, 403, 455, 516
315, 349, 405, 517
316, 458, 349, 517
317, 405, 514, 517
318, 400, 453, 518
319, 452, 400, 518
320, 453, 489, 518
321, 465, 413, 519
322, 413, 358, 519
323, 454, 516, 402
324, 408, 353, 520
325, 460, 408, 520
326, 353, 461, 520
327, 409, 354, 521
328, 461, 409, 521
329, 354, 462, 521
330, 410, 355, 522
331, 411, 356, 523
332, 412, 357, 524
333, 358, 466, 519
334, 402, 516, 525
335, 489, 402, 525
336, 516, 455, 525
337, 414, 359, 526
338, 466, 414, 526
339, 359, 467, 526
340, 415, 360, 527
341, 416, 361, 528
342, 417, 362, 529
343, 377, 491, 429
344, 477, 368, 530
345, 368, 424, 530
346, 463, 411, 523
347, 366, 422, 531
348, 367, 423, 532
349, 424, 478, 530
350, 427, 494, 481
351, 462, 410, 522
352, 522, 355, 463
353, 426, 486, 483
354, 497, 385, 533
355, 385, 438, 533
356, 431, 379, 534
357, 495, 383, 535
358, 383, 436, 535
359, 382, 435, 536
360, 436, 496, 535
361, 382, 536, 480
362, 384, 437, 537
363, 438, 498, 533
364, 431, 534, 482
365, 386, 439, 538
366, 498, 386, 538
367, 439, 499, 538
368, 387, 440, 539
369, 499, 387, 539
370, 440, 500, 539
371, 388, 441, 540
372, 389, 442, 541
373, 390, 443, 542
374, 502, 390, 542
375, 443, 503, 542
376, 391, 444, 543
377, 392, 445, 544
378, 393, 446, 545
379, 446, 506, 545
380, 394, 447, 546
381, 395, 448, 547
382, 396, 449, 548
383, 397, 450, 549
384, 398, 451, 550
385, 399, 452, 551
386, 511, 399, 551
387, 452, 518, 551
388, 510, 398, 550
389, 509, 397, 549
390, 508, 396, 548
391, 418, 363, 552
392, 363, 473, 552
393, 507, 395, 547
394, 506, 394, 546
395, 505, 393, 545
396, 504, 392, 544
397, 425, 370, 553
398, 370, 487, 553
399, 503, 391, 543
400, 543, 444, 504
401, 501, 389, 541
402, 500, 388, 540
403, 540, 441, 501
404, 384, 537, 496
405, 471, 366, 531
406, 469, 417, 529
407, 468, 416, 528
408, 467, 415, 527
409, 527, 360, 468
410, 524, 357, 465
411, 523, 356, 464
412, 412, 524, 464
413, 529, 362, 554
414, 362, 418, 554
415, 528, 361, 469
416, 532, 423, 477
417, 531, 422, 476
418, 367, 532, 476
419, 550, 451, 511
420, 549, 450, 510
421, 548, 449, 509
422, 534, 379, 492
423, 536, 435, 495
424, 547, 448, 508
425, 537, 437, 497
426, 541, 442, 502
427, 544, 445, 505
428, 546, 447, 507
429, 507, 547, 555
430, 522, 463, 556
431, 483, 486, 557
432, 469, 529, 558
433, 464, 524, 559
434, 523, 464, 560
435, 464, 559, 560
436, 519, 466, 561
437, 527, 468, 562
438, 467, 527, 563
439, 527, 562, 563
440, 532, 477, 564
441, 481, 494, 565
442, 528, 469, 566
443, 469, 558, 566
444, 550, 511, 567
445, 476, 532, 568
446, 532, 564, 568
447, 531, 476, 569
448, 476, 568, 569
449, 530, 478, 570
450, 463, 523, 571
451, 556, 463, 571
452, 523, 560, 571
453, 536, 495, 572
454, 369, 425, 573
455, 465, 519, 574
456, 519, 561, 574
457, 503, 543, 575
458, 477, 530, 576
459, 564, 477, 576
460, 530, 570, 576
461, 480, 536, 577
462, 536, 572, 577
463, 487, 481, 578
464, 553, 487, 578
465, 481, 565, 578
466, 514, 457, 579
467, 482, 534, 580
468, 518, 489, 551
469, 492, 479, 581
470, 494, 483, 582
471, 483, 557, 582
472, 488, 482, 583
473, 482, 580, 583
474, 471, 531, 584
475, 531, 569, 584
476, 535, 496, 585
477, 541, 502, 586
478, 533, 498, 587
479, 545, 506, 588
480, 540, 501, 589
481, 500, 540, 590
482, 540, 589, 590
483, 544, 505, 591
484, 501, 541, 592
485, 589, 501, 592
486, 541, 586, 592
487, 546, 507, 593
488, 507, 555, 593
489, 504, 544, 594
490, 544, 591, 594
491, 505, 545, 595
492, 591, 505, 595
493, 545, 588, 595
494, 506, 546, 596
495, 588, 506, 596
496, 546, 593, 596
497, 534, 492, 597
498, 492, 581, 597
499, 508, 548, 598
500, 509, 549, 599
501, 549, 510, 599
502, 510, 550, 600
503, 550, 567, 600
504, 497, 533, 601
505, 533, 587, 601
506, 462, 522, 602
507, 522, 556, 602
508, 478, 369, 573
509, 473, 470, 603
510, 573, 619, 478
511, 573, 425, 553
512, 520, 461, 604
513, 459, 513, 605
514, 521, 462, 606
515, 462, 602, 606
516, 461, 521, 607
517, 604, 461, 607
518, 521, 606, 607
519, 587, 498, 608
520, 498, 538, 608
521, 554, 418, 552
522, 561, 466, 609
523, 466, 526, 609
524, 525, 455, 610
525, 455, 515, 610
526, 586, 502, 611
527, 502, 542, 611
528, 524, 465, 612
529, 559, 524, 612
530, 465, 574, 612
531, 468, 528, 613
532, 562, 468, 613
533, 528, 566, 613
534, 456, 474, 614
535, 429, 491, 485
536, 474, 471, 615
537, 614, 474, 615
538, 471, 584, 615
539, 573, 553, 578
540, 475, 493, 616
541, 565, 494, 582
542, 547, 508, 617
543, 484, 485, 491
544, 539, 500, 618
545, 500, 590, 618
546, 580, 534, 597
547, 573, 578, 619
548, 570, 478, 619
549, 578, 565, 619
550, 490, 475, 620
551, 475, 616, 620
552, 551, 489, 621
553, 511, 551, 621
554, 489, 525, 621
555, 581, 479, 622
556, 479, 490, 622
557, 495, 535, 623
558, 535, 585, 623
559, 547, 617, 555
560, 493, 480, 624
561, 616, 493, 624
562, 480, 577, 624
563, 585, 496, 625
564, 496, 537, 625
565, 558, 529, 626
566, 529, 554, 626
567, 499, 539, 627
568, 539, 618, 627
569, 542, 503, 628
570, 611, 542, 628
571, 503, 575, 628
572, 543, 504, 629
573, 575, 543, 629
574, 504, 594, 629
575, 572, 495, 623
576, 510, 600, 599
577, 537, 497, 630
578, 625, 537, 630
579, 497, 601, 630
580, 598, 548, 631
581, 548, 509, 631
582, 509, 599, 631
583, 460, 520, 632
584, 520, 604, 632
585, 513, 460, 633
586, 605, 513, 633
587, 460, 632, 633
588, 512, 459, 634
589, 459, 605, 634
590, 552, 473, 635
591, 473, 603, 635
592, 486, 484, 636
593, 557, 486, 636
594, 484, 491, 636
595, 491, 488, 636
596, 603, 470, 637
597, 470, 472, 637
598, 472, 456, 638
599, 637, 472, 638
600, 456, 614, 638
601, 511, 621, 567
602, 617, 508, 598
603, 636, 488, 583
604, 636, 583, 557
605, 499, 627, 608
606, 587, 608, 639
607, 597, 581, 640
608, 557, 583, 641
609, 598, 631, 634
610, 555, 617, 633
611, 467, 563, 609
612, 577, 572, 642
613, 514, 579, 643
614, 617, 598, 605
615, 574, 561, 644
616, 585, 625, 645
617, 569, 568, 646
618, 566, 558, 647
619, 514, 643, 517
620, 467, 609, 526
621, 517, 643, 458
622, 499, 608, 538
623, 563, 562, 648
624, 582, 557, 641
625, 621, 525, 610
626, 458, 643, 649
627, 623, 585, 650
628, 585, 645, 650
629, 599, 600, 579
630, 583, 580, 641
631, 584, 569, 651
632, 569, 646, 651
633, 560, 559, 652
634, 580, 597, 653
635, 597, 640, 653
636, 609, 563, 654
637, 563, 648, 654
638, 594, 591, 655
639, 572, 623, 656
640, 642, 572, 656
641, 623, 650, 656
642, 561, 609, 657
643, 644, 561, 657
644, 609, 654, 657
645, 605, 598, 634
646, 631, 599, 579
647, 457, 512, 658
648, 458, 649, 515
649, 457, 658, 579
650, 658, 512, 634
651, 601, 587, 659
652, 587, 639, 659
653, 602, 556, 655
654, 554, 552, 660
655, 626, 554, 660
656, 552, 635, 660
657, 608, 627, 661
658, 602, 655, 662
659, 606, 602, 662
660, 655, 591, 662
661, 631, 579, 658
662, 586, 611, 663
663, 608, 661, 639
664, 555, 633, 664
665, 593, 555, 664
666, 633, 632, 664
667, 610, 515, 649
668, 629, 594, 665
669, 594, 655, 665
670, 612, 574, 663
671, 576, 570, 653
672, 617, 605, 633
673, 615, 584, 666
674, 584, 651, 666
675, 567, 621, 610
676, 574, 644, 663
677, 560, 652, 665
678, 568, 564, 667
679, 556, 571, 655
680, 648, 562, 661
681, 565, 582, 668
682, 646, 568, 667
683, 582, 641, 668
684, 593, 664, 596
685, 490, 620, 622
686, 649, 643, 600
687, 579, 600, 643
688, 641, 580, 653
689, 661, 627, 648
690, 588, 596, 669
691, 596, 664, 669
692, 591, 595, 662
693, 631, 658, 634
694, 664, 632, 604
695, 589, 592, 657
696, 559, 612, 670
697, 652, 559, 670
698, 612, 663, 670
699, 645, 625, 671
700, 625, 630, 671
701, 595, 588, 672
702, 662, 595, 672
703, 588, 669, 672
704, 630, 601, 673
705, 671, 630, 673
706, 601, 659, 673
707, 600, 567, 649
708, 586, 663, 644
709, 635, 603, 674
710, 614, 615, 675
711, 615, 666, 675
712, 664, 604, 669
713, 669, 604, 607
714, 592, 586, 644
715, 590, 589, 654
716, 653, 570, 641
717, 590, 654, 648
718, 606, 662, 672
719, 663, 611, 670
720, 639, 661, 647
721, 607, 606, 672
722, 560, 665, 571
723, 577, 642, 676
724, 611, 628, 670
725, 667, 564, 677
726, 637, 638, 678
727, 665, 652, 629
728, 577, 676, 624
729, 676, 642, 675
730, 677, 564, 576
731, 675, 642, 679
732, 614, 675, 679
733, 642, 656, 679
734, 566, 647, 613
735, 661, 562, 647
736, 565, 668, 619
737, 640, 581, 680
738, 614, 679, 638
739, 680, 581, 622
740, 638, 679, 678
741, 650, 645, 674
742, 618, 590, 648
743, 640, 680, 667
744, 676, 675, 666
745, 669, 607, 672
746, 570, 619, 668
747, 628, 575, 652
748, 558, 626, 681
749, 622, 620, 680
750, 647, 558, 681
751, 628, 652, 670
752, 674, 645, 671
753, 667, 680, 646
754, 646, 680, 682
755, 651, 646, 682
756, 680, 620, 682
757, 616, 624, 676
758, 589, 657, 654
759, 659, 639, 681
760, 674, 603, 678
761, 603, 637, 678
762, 639, 647, 681
763, 620, 616, 682
764, 659, 681, 673
765, 616, 676, 682
766, 678, 679, 656
767, 681, 626, 683
768, 657, 592, 644
769, 650, 674, 678
770, 635, 674, 683
771, 575, 629, 652
772, 665, 655, 571
773, 674, 671, 683
774, 682, 676, 651
775, 649, 567, 610
776, 653, 640, 677
777, 676, 666, 651
778, 650, 678, 656
779, 677, 640, 667
780, 648, 627, 618
781, 681, 683, 673
782, 660, 635, 683
783, 673, 683, 671
784, 660, 683, 626
785, 677, 576, 653
786, 562, 613, 647
787, 570, 668, 641
788, 133, 4, 128
789, 5, 133, 684
790, 134, 5, 684
791, 133, 128, 684
792, 135, 134, 685
793, 134, 684, 685
794, 136, 135, 686
795, 135, 685, 686
796, 137, 136, 687
797, 136, 686, 687
798, 138, 137, 688
799, 137, 687, 688
800, 140, 139, 689
801, 141, 140, 690
802, 140, 689, 690
803, 142, 141, 691
804, 143, 142, 692
805, 142, 691, 692
806, 144, 143, 693
807, 145, 144, 694
808, 144, 693, 694
809, 146, 145, 695
810, 147, 146, 696
811, 146, 695, 696
812, 148, 147, 697
813, 149, 148, 698
814, 148, 697, 698
815, 150, 149, 699
816, 151, 150, 700
817, 150, 699, 700
818, 152, 151, 701
819, 153, 152, 702
820, 152, 701, 702
821, 154, 153, 703
822, 155, 154, 704
823, 154, 703, 704
824, 156, 155, 705
825, 157, 156, 706
826, 156, 705, 706
827, 158, 157, 707
828, 159, 158, 708
829, 158, 707, 708
830, 160, 159, 709
831, 161, 160, 710
832, 160, 709, 710
833, 162, 161, 711
834, 163, 162, 712
835, 162, 711, 712
836, 164, 163, 713
837, 165, 164, 714
838, 164, 713, 714
839, 166, 165, 715
840, 167, 166, 716
841, 166, 715, 716
842, 168, 167, 717
843, 169, 168, 718
844, 168, 717, 718
845, 170, 169, 719
846, 171, 170, 720
847, 170, 719, 720
848, 172, 171, 721
849, 173, 172, 722
850, 172, 721, 722
851, 174, 173, 723
852, 175, 174, 724
853, 174, 723, 724
854, 176, 175, 725
855, 177, 176, 726
856, 176, 725, 726
857, 178, 177, 727
858, 179, 178, 728
859, 178, 727, 728
860, 180, 179, 729
861, 181, 180, 81
862, 182, 181, 80
863, 6, 182, 183
864, 3, 183, 80
865, 81, 80, 181
866, 82, 81, 180
867, 84, 83, 728
868, 85, 84, 727
869, 86, 85, 726
870, 87, 86, 725
871, 88, 87, 724
872, 89, 88, 723
873, 90, 89, 722
874, 91, 90, 721
875, 92, 91, 720
876, 93, 92, 719
877, 94, 93, 718
878, 95, 94, 717
879, 96, 95, 716
880, 97, 96, 715
881, 98, 97, 714
882, 99, 98, 713
883, 100, 99, 712
884, 101, 100, 711
885, 102, 101, 710
886, 103, 102, 709
887, 104, 103, 708
888, 105, 104, 707
889, 106, 105, 706
890, 107, 106, 705
891, 108, 107, 704
892, 109, 108, 703
893, 110, 109, 702
894, 111, 110, 701
895, 112, 111, 700
896, 113, 112, 699
897, 114, 113, 698
898, 115, 114, 697
899, 116, 115, 696
900, 117, 116, 695
901, 118, 117, 694
902, 119, 118, 693
903, 120, 119, 692
904, 121, 120, 691
905, 122, 121, 690
906, 123, 122, 689
907, 124, 123, 688
908, 125, 124, 687
909, 126, 125, 686
910, 127, 126, 685
911, 128, 127, 684
912, 182, 80, 183
913, 139, 138, 730
914, 689, 139, 730
915, 138, 688, 730
916, 141, 690, 691
917, 143, 692, 693
918, 145, 694, 695
919, 147, 696, 697
920, 149, 698, 699
921, 151, 700, 701
922, 153, 702, 703
923, 155, 704, 705
924, 157, 706, 707
925, 159, 708, 709
926, 161, 710, 711
927, 163, 712, 713
928, 165, 714, 715
929, 167, 716, 717
930, 169, 718, 719
931, 171, 720, 721
932, 173, 722, 723
933, 175, 724, 725
934, 177, 726, 727
935, 179, 728, 729
936, 723, 88, 724
937, 724, 87, 725
938, 725, 86, 726
939, 726, 85, 727
940, 728, 83, 729
941, 83, 82, 729
942, 89, 723, 722
943, 90, 722, 721
944, 91, 721, 720
945, 92, 720, 719
946, 93, 719, 718
947, 94, 718, 717
948, 95, 717, 716
949, 96, 716, 715
950, 97, 715, 714
951, 98, 714, 713
952, 99, 713, 712
953, 100, 712, 711
954, 101, 711, 710
955, 102, 710, 709
956, 103, 709, 708
957, 104, 708, 707
958, 105, 707, 706
959, 106, 706, 705
960, 107, 705, 704
961, 108, 704, 703
962, 109, 703, 702
963, 110, 702, 701
964, 111, 701, 700
965, 112, 700, 699
966, 113, 699, 698
967, 114, 698, 697
968, 115, 697, 696
969, 116, 696, 695
970, 117, 695, 694
971, 118, 694, 693
972, 119, 693, 692
973, 120, 692, 691
974, 121, 691, 690
975, 122, 690, 689
976, 125, 687, 686
977, 126, 686, 685
978, 127, 685, 684
979, 84, 728, 727
980, 687, 124, 688
981, 123, 689, 730
982, 123, 730, 688
983, 82, 180, 729
984, 6, 183, 184
985, 183, 3, 185
986, 183, 185, 184
987, 7, 184, 185
988, 8, 7, 185
989, 6, 184, 192
990, 184, 7, 186
991, 186, 187, 193
992, 187, 188, 11
993, 188, 189, 191
994, 189, 9, 190
995, 190, 10, 191
996, 191, 11, 188
997, 193, 192, 186
998, 11, 193, 187
999, 192, 184, 186
1000, 191, 189, 190
1001, 7, 212, 186
1002, 731, 186, 212
1003, 187, 186, 732
1004, 186, 731, 732
1005, 188, 187, 733
1006, 187, 732, 733
1007, 189, 188, 734
1008, 188, 733, 734
1009, 9, 189, 734
1010, 194, 9, 734
1011, 195, 194, 735
1012, 194, 734, 735
1013, 196, 195, 736
1014, 195, 735, 736
1015, 197, 196, 737
1016, 196, 736, 737
1017, 198, 197, 738
1018, 197, 737, 738
1019, 199, 198, 739
1020, 198, 738, 739
1021, 12, 199, 200
1022, 202, 201, 740
1023, 203, 202, 741
1024, 202, 740, 741
1025, 13, 203, 742
1026, 204, 13, 742
1027, 203, 741, 742
1028, 205, 204, 743
1029, 204, 742, 743
1030, 206, 205, 744
1031, 205, 743, 744
1032, 207, 206, 745
1033, 206, 744, 745
1034, 208, 207, 746
1035, 207, 745, 746
1036, 209, 208, 747
1037, 208, 746, 747
1038, 210, 209, 748
1039, 209, 747, 748
1040, 211, 210, 749
1041, 210, 748, 749
1042, 749, 731, 211
1043, 200, 199, 739
1044, 201, 200, 739
1045, 201, 739, 740
1046, 733, 732, 750
1047, 736, 735, 751
1048, 737, 736, 752
1049, 736, 751, 752
1050, 738, 737, 753
1051, 737, 752, 753
1052, 739, 738, 754
1053, 740, 739, 754
1054, 738, 753, 754
1055, 741, 740, 755
1056, 742, 741, 755
1057, 740, 754, 755
1058, 212, 211, 731
1059, 743, 742, 755
1060, 744, 743, 756
1061, 743, 755, 756
1062, 745, 744, 757
1063, 744, 756, 757
1064, 746, 745, 758
1065, 745, 757, 758
1066, 747, 746, 759
1067, 746, 758, 759
1068, 748, 747, 760
1069, 747, 759, 760
1070, 732, 731, 761
1071, 750, 732, 761
1072, 731, 749, 761
1073, 734, 733, 735
1074, 735, 733, 750
1075, 751, 735, 750
1076, 749, 748, 762
1077, 762, 748, 760
1078, 749, 762, 761
1079, 753, 752, 758
1080, 750, 761, 762
1081, 756, 755, 754
1082, 758, 757, 753
1083, 759, 758, 752
1084, 751, 760, 752
1085, 750, 762, 751
1086, 756, 754, 753
1087, 759, 752, 760
1088, 760, 751, 762
1089, 756, 753, 757
1090, 213, 14, 217
1091, 13, 213, 203
1092, 12, 200, 214
1093, 200, 201, 215
1094, 201, 202, 16
1095, 202, 203, 216
1096, 15, 214, 215
1097, 16, 215, 201
1098, 216, 16, 202
1099, 217, 216, 203
1100, 203, 213, 217
1101, 215, 214, 200
1102, 16, 216, 763
1103, 14, 218, 217
1104, 764, 217, 218
1105, 218, 219, 764
1106, 219, 220, 765
1107, 221, 222, 766
1108, 223, 224, 767
1109, 225, 226, 768
1110, 227, 228, 769
1111, 229, 230, 770
1112, 231, 232, 771
1113, 233, 234, 772
1114, 235, 236, 773
1115, 237, 238, 774
1116, 239, 240, 775
1117, 241, 242, 776
1118, 243, 244, 777
1119, 245, 246, 778
1120, 247, 248, 779
1121, 249, 250, 780
1122, 251, 252, 781
1123, 253, 254, 782
1124, 255, 256, 783
1125, 257, 258, 784
1126, 259, 260, 785
1127, 261, 262, 786
1128, 263, 264, 787
1129, 265, 266, 788
1130, 266, 17, 789
1131, 788, 266, 789
1132, 17, 267, 789
1133, 18, 268, 790
1134, 268, 19, 791
1135, 790, 268, 791
1136, 19, 269, 791
1137, 270, 271, 792
1138, 272, 273, 793
1139, 274, 275, 794
1140, 276, 277, 795
1141, 278, 279, 796
1142, 280, 281, 797
1143, 282, 283, 798
1144, 284, 285, 799
1145, 286, 287, 800
1146, 288, 289, 801
1147, 290, 291, 802
1148, 292, 293, 803
1149, 294, 295, 804
1150, 296, 297, 805
1151, 298, 299, 806
1152, 300, 15, 215
1153, 215, 16, 807
1154, 16, 763, 807
1155, 300, 215, 807
1156, 217, 764, 216
1157, 766, 222, 808
1158, 222, 223, 808
1159, 764, 219, 765
1160, 765, 220, 809
1161, 220, 221, 809
1162, 221, 766, 809
1163, 223, 767, 808
1164, 224, 225, 810
1165, 225, 768, 810
1166, 226, 227, 811
1167, 227, 769, 811
1168, 228, 229, 812
1169, 229, 770, 812
1170, 230, 231, 813
1171, 231, 771, 813
1172, 232, 233, 814
1173, 233, 772, 814
1174, 234, 235, 815
1175, 235, 773, 815
1176, 236, 237, 816
1177, 237, 774, 816
1178, 238, 239, 817
1179, 239, 775, 817
1180, 240, 241, 818
1181, 241, 776, 818
1182, 242, 243, 819
1183, 243, 777, 819
1184, 244, 245, 820
1185, 245, 778, 820
1186, 246, 247, 821
1187, 247, 779, 821
1188, 248, 249, 822
1189, 249, 780, 822
1190, 250, 251, 823
1191, 251, 781, 823
1192, 252, 253, 824
1193, 253, 782, 824
1194, 254, 255, 825
1195, 255, 783, 825
1196, 256, 257, 826
1197, 257, 784, 826
1198, 258, 259, 827
1199, 259, 785, 827
1200, 260, 261, 828
1201, 261, 786, 828
1202, 262, 263, 829
1203, 263, 787, 829
1204, 264, 265, 830
1205, 265, 788, 830
1206, 267, 18, 831
1207, 793, 273, 832
1208, 273, 274, 832
1209, 269, 270, 833
1210, 271, 272, 834
1211, 274, 794, 832
1212, 275, 276, 835
1213, 277, 278, 836
1214, 279, 280, 837
1215, 281, 282, 838
1216, 283, 284, 839
1217, 285, 286, 840
1218, 287, 288, 841
1219, 289, 290, 842
1220, 291, 292, 843
1221, 293, 294, 844
1222, 295, 296, 845
1223, 297, 298, 846
1224, 837, 280, 797
1225, 299, 300, 847
1226, 216, 764, 763
1227, 838, 282, 798
1228, 300, 807, 847
1229, 767, 224, 810
1230, 768, 226, 811
1231, 769, 228, 812
1232, 770, 230, 813
1233, 771, 232, 814
1234, 772, 234, 815
1235, 773, 236, 816
1236, 774, 238, 817
1237, 775, 240, 818
1238, 776, 242, 819
1239, 777, 244, 820
1240, 778, 246, 821
1241, 779, 248, 822
1242, 780, 250, 823
1243, 781, 252, 824
1244, 782, 254, 825
1245, 783, 256, 826
1246, 784, 258, 827
1247, 785, 260, 828
1248, 786, 262, 829
1249, 787, 264, 830
1250, 792, 271, 834
1251, 789, 267, 831
1252, 794, 275, 835
1253, 795, 277, 836
1254, 796, 279, 837
1255, 797, 281, 838
1256, 798, 283, 839
1257, 799, 285, 840
1258, 800, 287, 841
1259, 801, 289, 842
1260, 802, 291, 843
1261, 803, 293, 844
1262, 804, 295, 845
1263, 805, 297, 846
1264, 806, 299, 847
1265, 839, 284, 799
1266, 840, 286, 800
1267, 841, 288, 801
1268, 842, 290, 802
1269, 843, 292, 803
1270, 844, 294, 804
1271, 845, 296, 805
1272, 846, 298, 806
1273, 836, 278, 796
1274, 834, 272, 793
1275, 831, 18, 790
1276, 833, 270, 792
1277, 835, 276, 795
1278, 768, 811, 848
1279, 766, 808, 849
1280, 795, 836, 850
1281, 809, 766, 851
1282, 766, 849, 851
1283, 810, 768, 852
1284, 768, 848, 852
1285, 769, 812, 853
1286, 811, 769, 854
1287, 769, 853, 854
1288, 770, 813, 855
1289, 812, 770, 856
1290, 770, 855, 856
1291, 771, 814, 857
1292, 813, 771, 858
1293, 771, 857, 858
1294, 772, 815, 859
1295, 814, 772, 860
1296, 772, 859, 860
1297, 773, 816, 861
1298, 815, 773, 862
1299, 773, 861, 862
1300, 774, 817, 863
1301, 816, 774, 864
1302, 774, 863, 864
1303, 775, 818, 865
1304, 817, 775, 866
1305, 775, 865, 866
1306, 776, 819, 867
1307, 818, 776, 868
1308, 776, 867, 868
1309, 777, 820, 869
1310, 819, 777, 870
1311, 777, 869, 870
1312, 778, 821, 871
1313, 820, 778, 872
1314, 778, 871, 872
1315, 779, 822, 873
1316, 821, 779, 874
1317, 779, 873, 874
1318, 780, 823, 875
1319, 822, 780, 876
1320, 780, 875, 876
1321, 781, 824, 877
1322, 823, 781, 878
1323, 781, 877, 878
1324, 782, 825, 850
1325, 824, 782, 850
1326, 783, 826, 879
1327, 825, 783, 880
1328, 783, 879, 880
1329, 784, 827, 881
1330, 826, 784, 882
1331, 784, 881, 882
1332, 785, 828, 883
1333, 827, 785, 884
1334, 785, 883, 884
1335, 786, 829, 885
1336, 828, 786, 886
1337, 786, 885, 886
1338, 787, 830, 887
1339, 829, 787, 888
1340, 787, 887, 888
1341, 792, 834, 888
1342, 835, 879, 794
1343, 788, 789, 831
1344, 791, 269, 833
1345, 793, 832, 883
1346, 790, 791, 833
1347, 835, 795, 880
1348, 831, 790, 833
1349, 832, 794, 882
1350, 796, 837, 875
1351, 797, 838, 874
1352, 839, 799, 870
1353, 839, 869, 798
1354, 847, 807, 889
1355, 807, 763, 889
1356, 799, 840, 868
1357, 866, 865, 800
1358, 800, 841, 866
1359, 841, 801, 864
1360, 801, 842, 862
1361, 860, 859, 802
1362, 802, 843, 860
1363, 843, 803, 855
1364, 853, 856, 844
1365, 844, 804, 853
1366, 804, 845, 848
1367, 849, 892, 846
1368, 846, 806, 849
1369, 889, 893, 847
1370, 836, 796, 877
1371, 767, 810, 890
1372, 810, 852, 890
1373, 763, 764, 889
1374, 838, 798, 872
1375, 788, 831, 891
1376, 830, 788, 891
1377, 831, 833, 891
1378, 889, 764, 765
1379, 795, 850, 880
1380, 808, 767, 892
1381, 811, 854, 848
1382, 855, 813, 858
1383, 859, 815, 862
1384, 861, 816, 864
1385, 865, 818, 868
1386, 867, 819, 870
1387, 871, 821, 874
1388, 873, 822, 876
1389, 875, 823, 878
1390, 877, 824, 850
1391, 850, 825, 880
1392, 879, 826, 882
1393, 881, 827, 884
1394, 883, 828, 886
1395, 885, 829, 888
1396, 887, 830, 891
1397, 850, 836, 877
1398, 833, 792, 891
1399, 875, 837, 876
1400, 793, 883, 886
1401, 797, 874, 873
1402, 834, 793, 886
1403, 848, 845, 852
1404, 845, 805, 890
1405, 767, 890, 892
1406, 837, 797, 876
1407, 765, 809, 893
1408, 876, 797, 873
1409, 893, 809, 851
1410, 845, 890, 852
1411, 853, 812, 856
1412, 857, 814, 860
1413, 863, 817, 866
1414, 869, 820, 872
1415, 888, 834, 885
1416, 796, 875, 878
1417, 870, 799, 867
1418, 883, 832, 884
1419, 808, 892, 849
1420, 889, 765, 893
1421, 835, 880, 879
1422, 874, 838, 871
1423, 792, 888, 887
1424, 839, 870, 869
1425, 868, 840, 865
1426, 864, 801, 861
1427, 801, 862, 861
1428, 842, 802, 859
1429, 855, 803, 856
1430, 853, 804, 854
1431, 890, 805, 892
1432, 877, 796, 878
1433, 799, 868, 867
1434, 854, 804, 848
1435, 842, 859, 862
1436, 885, 834, 886
1437, 884, 832, 881
1438, 806, 847, 893
1439, 882, 794, 879
1440, 843, 855, 858
1441, 841, 864, 863
1442, 806, 893, 851
1443, 843, 858, 857
1444, 805, 846, 892
1445, 792, 887, 891
1446, 843, 857, 860
1447, 841, 863, 866
1448, 840, 800, 865
1449, 803, 844, 856
1450, 849, 806, 851
1451, 838, 872, 871
1452, 872, 798, 869
1453, 832, 882, 881
1454, 301, 17, 266
1455, 1, 301, 22
1456, 23, 22, 266
1457, 24, 23, 265
1458, 25, 24, 264
1459, 26, 25, 263
1460, 27, 26, 261
1461, 28, 27, 260
1462, 29, 28, 259
1463, 30, 29, 258
1464, 31, 30, 257
1465, 32, 31, 256
1466, 33, 32, 255
1467, 34, 33, 254
1468, 35, 34, 253
1469, 36, 35, 252
1470, 37, 36, 251
1471, 38, 37, 250
1472, 39, 38, 249
1473, 40, 39, 248
1474, 41, 40, 247
1475, 42, 41, 246
1476, 43, 42, 245
1477, 44, 43, 244
1478, 45, 44, 243
1479, 46, 45, 242
1480, 47, 46, 241
1481, 48, 47, 240
1482, 49, 48, 239
1483, 50, 49, 238
1484, 51, 50, 237
1485, 52, 51, 236
1486, 53, 52, 235
1487, 54, 53, 234
1488, 55, 54, 233
1489, 56, 55, 232
1490, 57, 56, 231
1491, 58, 57, 230
1492, 59, 58, 229
1493, 60, 59, 228
1494, 61, 60, 227
1495, 62, 61, 226
1496, 63, 62, 225
1497, 64, 63, 224
1498, 65, 64, 223
1499, 66, 65, 222
1500, 67, 66, 221
1501, 68, 67, 220
1502, 69, 68, 219
1503, 70, 69, 218
1504, 2, 70, 302
1505, 14, 302, 218
1506, 219, 218, 69
1507, 220, 219, 68
1508, 221, 220, 67
1509, 222, 221, 66
1510, 223, 222, 65
1511, 224, 223, 64
1512, 225, 224, 63
1513, 226, 225, 62
1514, 227, 226, 61
1515, 228, 227, 60
1516, 229, 228, 59
1517, 230, 229, 58
1518, 231, 230, 57
1519, 232, 231, 56
1520, 233, 232, 55
1521, 234, 233, 54
1522, 235, 234, 53
1523, 236, 235, 52
1524, 237, 236, 51
1525, 238, 237, 50
1526, 239, 238, 49
1527, 240, 239, 48
1528, 241, 240, 47
1529, 242, 241, 46
1530, 243, 242, 45
1531, 244, 243, 44
1532, 245, 244, 43
1533, 246, 245, 42
1534, 247, 246, 41
1535, 248, 247, 40
1536, 249, 248, 39
1537, 250, 249, 38
1538, 251, 250, 37
1539, 252, 251, 36
1540, 253, 252, 35
1541, 254, 253, 34
1542, 255, 254, 33
1543, 256, 255, 32
1544, 257, 256, 31
1545, 258, 257, 30
1546, 259, 258, 29
1547, 260, 259, 28
1548, 261, 260, 27
1549, 264, 263, 25
1550, 265, 264, 24
1551, 266, 265, 23
1552, 22, 301, 266
1553, 70, 218, 302
1554, 26, 263, 262
1555, 26, 262, 261
1556, 14, 213, 302
1557, 2, 302, 303
1558, 303, 302, 213
1559, 213, 13, 303
1560, 13, 20, 303
1561, 8, 312, 212
1562, 7, 8, 212
1563, 304, 20, 204
1564, 305, 304, 205
1565, 306, 305, 206
1566, 307, 306, 207
1567, 989, 910, 935
1568, 983, 943, 986
1569, 309, 209, 310
1570, 943, 1003, 986
1571, 312, 311, 211
1572, 308, 307, 208
1573, 211, 311, 210
1574, 309, 308, 209
1575, 305, 205, 206
1576, 306, 206, 207
1577, 307, 207, 208
1578, 312, 211, 212
1579, 205, 304, 204
1580, 13, 204, 20
1581, 940, 981, 988
1582, 311, 310, 210
1583, 980, 940, 1008
1584, 934, 975, 1009
1585, 209, 308, 208
1586, 210, 310, 209
1587, 20, 304, 303
1588, 304, 305, 894
1589, 305, 306, 895
1590, 306, 307, 896
1591, 307, 308, 897
1592, 308, 309, 898
1593, 309, 310, 899
1594, 310, 311, 900
1595, 311, 312, 901
1596, 312, 8, 902
1597, 901, 312, 902
1598, 8, 185, 902
1599, 2, 303, 71
1600, 72, 71, 894
1601, 73, 72, 895
1602, 74, 73, 896
1603, 75, 74, 897
1604, 76, 75, 898
1605, 77, 76, 899
1606, 78, 77, 900
1607, 79, 78, 901
1608, 3, 79, 902
1609, 303, 304, 894
1610, 894, 305, 895
1611, 306, 896, 895
1612, 307, 897, 896
1613, 308, 898, 897
1614, 309, 899, 898
1615, 310, 900, 899
1616, 311, 901, 900
1617, 896, 73, 895
1618, 894, 71, 303
1619, 72, 894, 895
1620, 74, 896, 897
1621, 75, 897, 898
1622, 76, 898, 899
1623, 77, 899, 900
1624, 78, 900, 901
1625, 79, 901, 902
1626, 185, 3, 902
1627, 11, 191, 903
1628, 191, 10, 313
1629, 313, 314, 904
1630, 315, 316, 905
1631, 317, 318, 906
1632, 319, 320, 907
1633, 321, 322, 908
1634, 323, 324, 909
1635, 325, 326, 910
1636, 327, 328, 911
1637, 329, 330, 912
1638, 331, 332, 913
1639, 333, 334, 914
1640, 335, 336, 915
1641, 337, 338, 916
1642, 339, 340, 917
1643, 341, 342, 918
1644, 343, 344, 919
1645, 344, 21, 345
1646, 345, 346, 920
1647, 346, 5, 134
1648, 134, 135, 921
1649, 136, 137, 922
1650, 138, 139, 923
1651, 140, 141, 924
1652, 142, 143, 925
1653, 144, 145, 926
1654, 146, 147, 927
1655, 148, 149, 928
1656, 150, 151, 929
1657, 152, 153, 930
1658, 154, 155, 931
1659, 156, 157, 932
1660, 158, 159, 933
1661, 160, 161, 934
1662, 162, 163, 935
1663, 164, 165, 936
1664, 166, 167, 937
1665, 168, 169, 938
1666, 170, 171, 939
1667, 172, 173, 940
1668, 174, 175, 941
1669, 176, 177, 942
1670, 178, 179, 943
1671, 180, 181, 944
1672, 182, 6, 192
1673, 192, 193, 945
1674, 193, 11, 946
1675, 945, 193, 946
1676, 11, 903, 946
1677, 191, 313, 903
1678, 346, 134, 921
1679, 182, 192, 945
1680, 313, 904, 903
1681, 314, 315, 947
1682, 316, 317, 948
1683, 318, 319, 949
1684, 320, 321, 950
1685, 321, 908, 950
1686, 322, 323, 951
1687, 324, 325, 952
1688, 326, 327, 953
1689, 328, 329, 954
1690, 330, 331, 955
1691, 331, 913, 955
1692, 332, 333, 956
1693, 334, 335, 957
1694, 336, 337, 958
1695, 338, 339, 959
1696, 340, 341, 960
1697, 341, 918, 960
1698, 342, 343, 961
1699, 344, 345, 919
1700, 920, 346, 921
1701, 345, 920, 919
1702, 949, 319, 907
1703, 921, 135, 962
1704, 135, 136, 962
1705, 182, 945, 181
1706, 136, 922, 962
1707, 181, 945, 944
1708, 137, 138, 963
1709, 139, 140, 964
1710, 141, 142, 965
1711, 143, 144, 966
1712, 145, 146, 967
1713, 147, 148, 968
1714, 149, 150, 969
1715, 151, 152, 970
1716, 153, 154, 971
1717, 155, 156, 972
1718, 157, 158, 973
1719, 159, 160, 974
1720, 161, 162, 975
1721, 163, 164, 976
1722, 165, 166, 977
1723, 167, 168, 978
1724, 169, 170, 979
1725, 938, 169, 979
1726, 170, 939, 979
1727, 171, 172, 980
1728, 173, 174, 981
1729, 175, 176, 982
1730, 177, 178, 983
1731, 179, 180, 984
1732, 948, 317, 906
1733, 952, 325, 910
1734, 953, 327, 911
1735, 314, 947, 904
1736, 905, 316, 948
1737, 906, 318, 949
1738, 907, 320, 950
1739, 908, 322, 951
1740, 909, 324, 952
1741, 910, 326, 953
1742, 911, 328, 954
1743, 912, 330, 955
1744, 913, 332, 956
1745, 914, 334, 957
1746, 915, 336, 958
1747, 916, 338, 959
1748, 917, 340, 960
1749, 918, 342, 961
1750, 922, 137, 963
1751, 923, 139, 964
1752, 924, 141, 965
1753, 925, 143, 966
1754, 926, 145, 967
1755, 927, 147, 968
1756, 928, 149, 969
1757, 929, 151, 970
1758, 930, 153, 971
1759, 931, 155, 972
1760, 932, 157, 973
1761, 933, 159, 974
1762, 934, 161, 975
1763, 935, 163, 976
1764, 936, 165, 977
1765, 937, 167, 978
1766, 980, 172, 940
1767, 939, 171, 980
1768, 940, 173, 981
1769, 941, 175, 982
1770, 942, 177, 983
1771, 943, 179, 984
1772, 954, 329, 912
1773, 957, 335, 915
1774, 958, 337, 916
1775, 959, 339, 917
1776, 970, 152, 930
1777, 971, 154, 931
1778, 972, 156, 932
1779, 973, 158, 933
1780, 974, 160, 934
1781, 975, 162, 935
1782, 976, 164, 936
1783, 977, 166, 937
1784, 978, 168, 938
1785, 982, 176, 942
1786, 983, 178, 943
1787, 984, 180, 944
1788, 947, 315, 905
1789, 951, 323, 909
1790, 956, 333, 914
1791, 961, 343, 919
1792, 969, 150, 929
1793, 968, 148, 928
1794, 967, 146, 927
1795, 966, 144, 926
1796, 965, 142, 925
1797, 964, 140, 924
1798, 963, 138, 923
1799, 981, 174, 941
1800, 950, 908, 985
1801, 905, 948, 986
1802, 951, 909, 987
1803, 906, 949, 988
1804, 952, 910, 989
1805, 908, 951, 990
1806, 985, 908, 990
1807, 951, 987, 990
1808, 909, 952, 991
1809, 987, 909, 991
1810, 952, 989, 991
1811, 956, 914, 992
1812, 910, 953, 975
1813, 911, 954, 993
1814, 904, 947, 994
1815, 912, 955, 995
1816, 957, 915, 996
1817, 914, 957, 997
1818, 992, 914, 997
1819, 957, 996, 997
1820, 961, 919, 998
1821, 915, 958, 927
1822, 958, 916, 926
1823, 959, 917, 999
1824, 969, 929, 997
1825, 949, 907, 940
1826, 981, 941, 988
1827, 963, 923, 1000
1828, 964, 924, 1001
1829, 965, 925, 999
1830, 928, 969, 997
1831, 929, 970, 992
1832, 968, 928, 996
1833, 930, 971, 1002
1834, 972, 932, 995
1835, 933, 974, 993
1836, 935, 976, 989
1837, 976, 936, 989
1838, 936, 977, 991
1839, 977, 937, 987
1840, 937, 978, 987
1841, 978, 938, 990
1842, 942, 983, 986
1843, 943, 984, 1003
1844, 984, 944, 994
1845, 954, 912, 1004
1846, 993, 954, 1004
1847, 912, 995, 1004
1848, 947, 905, 1003
1849, 948, 906, 1005
1850, 986, 948, 1005
1851, 906, 988, 1005
1852, 962, 922, 998
1853, 903, 904, 1006
1854, 946, 903, 1006
1855, 904, 994, 1006
1856, 919, 920, 998
1857, 923, 964, 1007
1858, 1000, 923, 1007
1859, 964, 1001, 1007
1860, 960, 918, 1007
1861, 905, 986, 1003
1862, 999, 917, 1001
1863, 956, 992, 1002
1864, 907, 950, 1008
1865, 921, 962, 920
1866, 975, 953, 1009
1867, 926, 916, 1010
1868, 975, 935, 910
1869, 953, 911, 1009
1870, 998, 920, 962
1871, 947, 1003, 994
1872, 913, 956, 1002
1873, 915, 927, 996
1874, 959, 999, 1010
1875, 916, 959, 1010
1876, 929, 992, 997
1877, 917, 960, 1001
1878, 970, 930, 992
1879, 918, 961, 1000
1880, 922, 963, 1011
1881, 949, 940, 988
1882, 995, 955, 1012
1883, 972, 995, 1012
1884, 955, 913, 1012
1885, 913, 1002, 1012
1886, 944, 945, 1006
1887, 1009, 911, 993
1888, 972, 1012, 931
1889, 998, 922, 1011
1890, 960, 1007, 1001
1891, 925, 966, 1010
1892, 928, 997, 996
1893, 966, 926, 1010
1894, 918, 1000, 1007
1895, 930, 1002, 992
1896, 971, 931, 1012
1897, 933, 993, 1004
1898, 932, 973, 1004
1899, 973, 933, 1004
1900, 974, 934, 1009
1901, 989, 936, 991
1902, 991, 977, 987
1903, 987, 978, 990
1904, 990, 938, 985
1905, 942, 986, 1005
1906, 982, 942, 1005
1907, 938, 979, 985
1908, 939, 980, 1008
1909, 941, 982, 1005
1910, 950, 985, 1008
1911, 984, 994, 1003
1912, 932, 1004, 995
1913, 945, 946, 1006
1914, 994, 944, 1006
1915, 993, 974, 1009
1916, 1002, 971, 1012
1917, 999, 925, 1010
1918, 979, 939, 985
1919, 988, 941, 1005
1920, 940, 907, 1008
1921, 985, 939, 1008
1922, 961, 998, 1011
1923, 927, 958, 967
1924, 958, 926, 967
1925, 1011, 963, 1000
1926, 1000, 961, 1011
1927, 924, 965, 999
1928, 927, 968, 996
1929, 924, 999, 1001
**
** Node sets +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Element sets ++++++++++++++++++++++++++++++++++++++++++++
**
*Elset, Elset=FDM
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 
17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 
33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 
49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 
65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 
97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 111, 112, 
113, 114, 115, 116, 117, 118, 119, 120, 121, 122, 123, 124, 125, 126, 127, 128, 
129, 130, 131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 141, 142, 143, 144, 
145, 146, 147, 148, 149, 150, 151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 171, 172, 173, 174, 175, 176, 
177, 178, 179, 180, 181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 191, 192, 
193, 194, 195, 196, 197, 198, 199, 200, 201, 202, 203, 204, 205, 206, 207, 208, 
209, 210, 211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 221, 222, 223, 224, 
225, 226, 227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 251, 252, 253, 254, 255, 256, 
257, 258, 259, 260, 261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 271, 272, 
273, 274, 275, 276, 277, 278, 279, 280, 281, 282, 283, 284, 285, 286, 287, 288, 
289, 290, 291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 301, 302, 303, 304, 
305, 306, 307, 308, 309, 310, 311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 331, 332, 333, 334, 335, 336, 
337, 338, 339, 340, 341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 351, 352, 
353, 354, 355, 356, 357, 358, 359, 360, 361, 362, 363, 364, 365, 366, 367, 368, 
369, 370, 371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 381, 382, 383, 384, 
385, 386, 387, 388, 389, 390, 391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 411, 412, 413, 414, 415, 416, 
417, 418, 419, 420, 421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 431, 432, 
433, 434, 435, 436, 437, 438, 439, 440, 441, 442, 443, 444, 445, 446, 447, 448, 
449, 450, 451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 463, 464, 
465, 466, 467, 468, 469, 470, 471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 491, 492, 493, 494, 495, 496, 
497, 498, 499, 500, 501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 518, 519, 520, 521, 522, 523, 524, 525, 526, 527, 528, 
529, 530, 531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 541, 542, 543, 544, 
545, 546, 547, 548, 549, 550, 551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 571, 572, 573, 574, 575, 576, 
577, 578, 579, 580, 581, 582, 583, 584, 585, 586, 587, 588, 589, 590, 591, 592, 
593, 594, 595, 596, 597, 598, 599, 600, 601, 602, 603, 604, 605, 606, 607, 608, 
609, 610, 611, 612, 613, 614, 615, 616, 617, 618, 619, 620, 621, 622, 623, 624, 
625, 626, 627, 628, 629, 630, 631, 632, 633, 634, 635, 636, 637, 638, 639, 640, 
641, 642, 643, 644, 645, 646, 647, 648, 649, 650, 651, 652, 653, 654, 655, 656, 
657, 658, 659, 660, 661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 671, 672, 
673, 674, 675, 676, 677, 678, 679, 680, 681, 682, 683, 684, 685, 686, 687, 688, 
689, 690, 691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 701, 702, 703, 704, 
705, 706, 707, 708, 709, 710, 711, 712, 713, 714, 715, 716, 717, 718, 719, 720, 
721, 722, 723, 724, 725, 726, 727, 728, 729, 730, 731, 732, 733, 734, 735, 736, 
737, 738, 739, 740, 741, 742, 743, 744, 745, 746, 747, 748, 749, 750, 751, 752, 
753, 754, 755, 756, 757, 758, 759, 760, 761, 762, 763, 764, 765, 766, 767, 768, 
769, 770, 771, 772, 773, 774, 775, 776, 777, 778, 779, 780, 781, 782, 783, 784, 
785, 786, 787
**
** Surfaces ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Physical constants ++++++++++++++++++++++++++++++++++++++
**
**
** Coordinate systems ++++++++++++++++++++++++++++++++++++++
**
**
** Materials +++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Sections ++++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Pre-tension sections ++++++++++++++++++++++++++++++++++++
**
**
** Constraints +++++++++++++++++++++++++++++++++++++++++++++
**
**
** Surface interactions ++++++++++++++++++++++++++++++++++++
**
**
** Contact pairs +++++++++++++++++++++++++++++++++++++++++++
**
**
** Amplitudes ++++++++++++++++++++++++++++++++++++++++++++++
**
**
** Initial conditions ++++++++++++++++++++++++++++++++++++++
**
**
** Steps +++++++++++++++++++++++++++++++++++++++++++++++++++
**
